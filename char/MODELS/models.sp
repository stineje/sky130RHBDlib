* SPICE
.LIB TT
.include "models.all"
.include "tt_discrete.cor"
.ENDL TT

.LIB FF
.include "models.all"
.include "ff_discrete.cor"
.ENDL FF

.LIB SS
.include "models.all"
.include "ss_discrete.cor"
.ENDL SS

.LIB FS
.include "models.all"
.include "fs_discrete.cor"
.ENDL FS

.LIB SF
.include "models.all"
.include "sf_discrete.cor"
.ENDL SF
