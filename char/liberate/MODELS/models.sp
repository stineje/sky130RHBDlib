* SPICE
.LIB TT
.include "models.all"
.include "tt_discrete.cor"
.ENDL TT
