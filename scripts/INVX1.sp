* FILE: INVX1.sp

* SPICE netlist for "INVX1" generated by MMI_SUE5.6.37 on Mon Jan 24
*+ 11:57:27 CST 2022.

.SUBCKT INVX1 A Y
M_1 Y A vdd vdd pshort W=2u L=0.150u ad='areap(2u,sdd)'
+ as='areap(2u,sdd)' pd='perip(2u,sdd)' ps='perip(2u,sdd)'
M_2 Y A vdd vdd pshort W=2u L=0.150u ad='areap(2u,sdd)'
+ as='areap(2u,sdd)' pd='perip(2u,sdd)' ps='perip(2u,sdd)'
M_3 Y A gnd gnd nshort W=3u L=0.150u ad='arean(3u,sdd)'
+ as='arean(3u,sdd)' pd='perin(3u,sdd)' ps='perin(3u,sdd)'
.ENDS	$ INVX1

X0 A Y INVX1

.GLOBAL gnd vdd
