VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO nmos_bottom
  CLASS BLOCK ;
  FOREIGN nmos_bottom ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.240 BY 1.510 ;
  OBS
      LAYER li1 ;
        RECT 0.050 1.300 0.220 1.380 ;
        RECT 1.020 1.300 1.190 1.380 ;
        RECT 0.050 1.130 1.190 1.300 ;
        RECT 0.050 0.000 0.220 1.130 ;
        RECT 0.535 0.425 0.705 0.755 ;
        RECT 1.020 0.000 1.190 1.130 ;
  END
END nmos_bottom
END LIBRARY

