VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO nmos_side_right
  CLASS BLOCK ;
  FOREIGN nmos_side_right ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.240 BY 1.510 ;
  OBS
      LAYER li1 ;
        RECT 0.050 1.300 0.220 1.380 ;
        RECT 1.020 1.300 1.190 1.380 ;
        RECT 0.050 1.130 1.190 1.300 ;
        RECT 0.050 1.040 0.220 1.130 ;
        RECT 0.535 0.455 0.705 0.880 ;
        RECT 0.050 0.250 0.220 0.340 ;
        RECT 1.020 0.250 1.190 1.130 ;
        RECT 0.050 0.080 1.190 0.250 ;
        RECT 0.050 0.000 0.220 0.080 ;
        RECT 1.020 0.000 1.190 0.080 ;
  END
END nmos_side_right
END LIBRARY

