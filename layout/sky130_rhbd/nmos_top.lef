VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO nmos_top
  CLASS BLOCK ;
  FOREIGN nmos_top ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.230 BY 1.540 ;
  OBS
      LAYER li1 ;
        RECT 0.040 0.250 0.210 1.380 ;
        RECT 0.530 0.470 0.700 0.805 ;
        RECT 1.010 0.250 1.180 1.380 ;
        RECT 0.040 0.080 1.180 0.250 ;
        RECT 0.040 0.000 0.210 0.080 ;
        RECT 1.010 0.000 1.180 0.080 ;
  END
END nmos_top
END LIBRARY

