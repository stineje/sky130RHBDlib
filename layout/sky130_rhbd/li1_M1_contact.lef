VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO li1_M1_contact
  CLASS BLOCK ;
  FOREIGN li1_M1_contact ;
  ORIGIN 0.265 0.165 ;
  SIZE 0.410 BY 0.330 ;
  OBS
      LAYER li1 ;
        RECT -0.085 -0.165 0.085 0.165 ;
      LAYER mcon ;
        RECT -0.085 -0.085 0.085 0.085 ;
      LAYER met1 ;
        RECT -0.115 0.085 0.115 0.115 ;
        RECT -0.265 -0.085 0.145 0.085 ;
        RECT -0.115 -0.115 0.115 -0.085 ;
  END
END li1_M1_contact
END LIBRARY

