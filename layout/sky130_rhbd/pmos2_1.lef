VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO pmos2_1
  CLASS BLOCK ;
  FOREIGN pmos2_1 ;
  ORIGIN -0.260 2.300 ;
  SIZE 1.500 BY 2.485 ;
  OBS
      LAYER nwell ;
        RECT 0.260 -2.175 1.760 0.185 ;
      LAYER li1 ;
        RECT 0.490 -1.465 0.660 -0.455 ;
        RECT 0.930 -1.465 1.100 -0.455 ;
        RECT 1.370 -1.465 1.540 -0.455 ;
  END
END pmos2_1
END LIBRARY

