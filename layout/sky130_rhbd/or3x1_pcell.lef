VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO or3x1_pcell
  CLASS BLOCK ;
  FOREIGN or3x1_pcell ;
  ORIGIN 1.915 0.170 ;
  SIZE 7.900 BY 7.920 ;
  OBS
      LAYER nwell ;
        RECT -1.915 3.930 5.985 7.750 ;
      LAYER pwell ;
        RECT -1.650 0.170 1.680 2.720 ;
        RECT 3.160 0.170 5.720 2.720 ;
        RECT -1.650 -0.170 5.720 0.170 ;
      LAYER li1 ;
        RECT -1.650 7.230 5.720 7.570 ;
        RECT -1.650 4.110 -1.310 7.230 ;
        RECT -0.775 5.295 -0.605 7.025 ;
        RECT -0.335 5.555 -0.165 7.230 ;
        RECT 0.105 6.825 1.155 6.995 ;
        RECT 0.105 5.295 0.275 6.825 ;
        RECT -0.775 5.125 0.275 5.295 ;
        RECT 0.545 5.295 0.715 6.565 ;
        RECT 0.985 5.555 1.155 6.825 ;
        RECT 1.585 6.825 2.635 6.995 ;
        RECT 1.585 5.295 1.755 6.825 ;
        RECT 0.545 5.125 1.755 5.295 ;
        RECT 2.025 5.295 2.195 6.565 ;
        RECT 2.465 5.555 2.635 6.825 ;
        RECT 2.025 5.125 2.305 5.295 ;
        RECT -0.610 4.710 -0.440 4.870 ;
        RECT 0.320 4.710 0.490 4.870 ;
        RECT -0.610 4.540 -0.285 4.710 ;
        RECT -1.650 0.170 -1.310 2.720 ;
        RECT -0.455 1.915 -0.285 4.540 ;
        RECT 0.285 4.540 0.490 4.710 ;
        RECT 0.285 1.915 0.455 4.540 ;
        RECT 1.395 1.915 1.565 4.870 ;
        RECT -0.870 0.615 -0.700 1.745 ;
        RECT 2.135 1.740 2.305 5.125 ;
        RECT 3.160 4.110 3.500 7.230 ;
        RECT 3.920 5.185 4.090 7.230 ;
        RECT -0.385 1.570 2.305 1.740 ;
        RECT -0.385 0.835 -0.215 1.570 ;
        RECT 0.100 0.615 0.270 1.390 ;
        RECT 0.585 0.835 0.755 1.570 ;
        RECT 1.070 0.615 1.240 1.390 ;
        RECT 1.555 0.835 1.725 1.570 ;
        RECT 2.040 0.615 2.210 1.390 ;
        RECT -0.870 0.445 2.210 0.615 ;
        RECT -0.870 0.170 -0.700 0.445 ;
        RECT -0.385 0.170 -0.215 0.445 ;
        RECT 0.100 0.170 0.270 0.445 ;
        RECT 0.585 0.170 0.755 0.445 ;
        RECT 1.070 0.170 1.240 0.445 ;
        RECT 1.555 0.170 1.725 0.445 ;
        RECT 2.040 0.170 2.210 0.445 ;
        RECT 3.160 0.170 3.500 2.720 ;
        RECT 3.985 1.920 4.155 4.865 ;
        RECT 4.360 4.665 4.530 7.020 ;
        RECT 4.800 5.185 4.970 7.230 ;
        RECT 4.360 4.495 4.895 4.665 ;
        RECT 4.725 2.165 4.895 4.495 ;
        RECT 5.380 4.110 5.720 7.230 ;
        RECT 4.355 1.995 4.895 2.165 ;
        RECT 3.875 0.620 4.045 1.750 ;
        RECT 4.355 0.840 4.525 1.995 ;
        RECT 4.845 0.620 5.015 1.750 ;
        RECT 3.875 0.450 5.015 0.620 ;
        RECT 3.875 0.170 4.045 0.450 ;
        RECT 4.360 0.170 4.530 0.450 ;
        RECT 4.845 0.170 5.015 0.450 ;
        RECT 5.380 0.170 5.720 2.720 ;
        RECT -1.650 -0.170 5.720 0.170 ;
      LAYER mcon ;
        RECT -1.195 7.315 -1.025 7.485 ;
        RECT -0.825 7.315 -0.655 7.485 ;
        RECT -0.455 7.315 -0.285 7.485 ;
        RECT -0.085 7.315 0.085 7.485 ;
        RECT 0.285 7.315 0.455 7.485 ;
        RECT 0.655 7.315 0.825 7.485 ;
        RECT 1.025 7.315 1.195 7.485 ;
        RECT 1.395 7.315 1.565 7.485 ;
        RECT 1.765 7.315 1.935 7.485 ;
        RECT 2.135 7.315 2.305 7.485 ;
        RECT 2.505 7.315 2.675 7.485 ;
        RECT 2.875 7.315 3.045 7.485 ;
        RECT 3.615 7.315 3.785 7.485 ;
        RECT 3.985 7.315 4.155 7.485 ;
        RECT 4.355 7.315 4.525 7.485 ;
        RECT 4.725 7.315 4.895 7.485 ;
        RECT 5.095 7.315 5.265 7.485 ;
        RECT 2.135 3.245 2.305 3.415 ;
        RECT 3.985 3.245 4.155 3.415 ;
        RECT -1.195 -0.085 -1.025 0.085 ;
        RECT -0.825 -0.085 -0.655 0.085 ;
        RECT -0.455 -0.085 -0.285 0.085 ;
        RECT -0.085 -0.085 0.085 0.085 ;
        RECT 0.285 -0.085 0.455 0.085 ;
        RECT 0.655 -0.085 0.825 0.085 ;
        RECT 1.025 -0.085 1.195 0.085 ;
        RECT 1.395 -0.085 1.565 0.085 ;
        RECT 1.765 -0.085 1.935 0.085 ;
        RECT 2.135 -0.085 2.305 0.085 ;
        RECT 2.505 -0.085 2.675 0.085 ;
        RECT 2.875 -0.085 3.045 0.085 ;
        RECT 3.615 -0.085 3.785 0.085 ;
        RECT 3.985 -0.085 4.155 0.085 ;
        RECT 4.355 -0.085 4.525 0.085 ;
        RECT 4.725 -0.085 4.895 0.085 ;
        RECT 5.095 -0.085 5.265 0.085 ;
      LAYER met1 ;
        RECT -1.650 7.230 5.720 7.570 ;
        RECT 2.105 3.415 2.335 3.445 ;
        RECT 3.955 3.415 4.185 3.445 ;
        RECT 2.075 3.245 4.215 3.415 ;
        RECT 2.105 3.215 2.335 3.245 ;
        RECT 3.955 3.215 4.185 3.245 ;
        RECT -1.650 -0.170 5.720 0.170 ;
  END
END or3x1_pcell
END LIBRARY

