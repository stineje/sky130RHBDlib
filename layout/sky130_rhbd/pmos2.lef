VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO pmos2
  CLASS BLOCK ;
  FOREIGN pmos2 ;
  ORIGIN -0.260 2.305 ;
  SIZE 1.500 BY 2.515 ;
  OBS
      LAYER nwell ;
        RECT 0.260 -2.180 1.760 0.180 ;
      LAYER li1 ;
        RECT 0.490 -1.465 0.660 0.210 ;
        RECT 0.930 -1.465 1.100 0.000 ;
        RECT 1.370 -1.465 1.540 0.210 ;
  END
END pmos2
END LIBRARY

