VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO poly_li1_contact
  CLASS BLOCK ;
  FOREIGN poly_li1_contact ;
  ORIGIN 0.160 0.140 ;
  SIZE 0.330 BY 0.270 ;
  OBS
      LAYER li1 ;
        RECT -0.160 -0.090 0.170 0.080 ;
  END
END poly_li1_contact
END LIBRARY

