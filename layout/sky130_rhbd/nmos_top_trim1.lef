VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO nmos_top_trim1
  CLASS BLOCK ;
  FOREIGN nmos_top_trim1 ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.240 BY 1.545 ;
  OBS
      LAYER li1 ;
        RECT 0.050 0.250 0.220 1.020 ;
        RECT 0.535 0.470 0.705 0.805 ;
        RECT 1.020 0.250 1.190 1.380 ;
        RECT 0.050 0.080 1.190 0.250 ;
        RECT 0.050 0.000 0.220 0.080 ;
        RECT 1.020 0.000 1.190 0.080 ;
  END
END nmos_top_trim1
END LIBRARY

