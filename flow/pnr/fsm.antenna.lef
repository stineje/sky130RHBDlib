

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO fsm 
  PIN done 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.5231 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5075 LAYER met2 ;
  END done
  PIN load_rega 
    ANTENNADIFFAREA 1.9191 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.6764 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.372 LAYER met2 ;
  END load_rega
  PIN load_regc 
    ANTENNADIFFAREA 1.9191 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.6666 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.225 LAYER met2 ;
  END load_regc
  PIN load_regb 
    ANTENNAPARTIALMETALAREA 0.5802 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.793 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2365 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0115 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.264 LAYER met3 ;
  END load_regb
  PIN load_regd 
    ANTENNADIFFAREA 1.9191 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.7607 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6955 LAYER met2 ;
  END load_regd
  PIN load_regr 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.9524 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.644 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met2 ; 
    ANTENNAMAXAREACAR 4.19887 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 18.8368 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0525831 LAYER via2 ;
  END load_regr
  PIN sel_muxr 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.9426 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.497 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met2 ; 
    ANTENNAMAXAREACAR 3.01033 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 14.8307 LAYER met2 ;
  END sel_muxr
  PIN load_regs 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1725 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6405 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 4.64964 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 21.7637 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END load_regs
  PIN sel_muxa[2] 
    ANTENNADIFFAREA 1.3391 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.8502 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.035 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met2 ; 
    ANTENNAMAXAREACAR 3.70522 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 16.3023 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0525831 LAYER via2 ;
  END sel_muxa[2]
  PIN sel_muxa[1] 
    ANTENNAPARTIALMETALAREA 0.5326 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.555 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2635 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.5668 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.16 LAYER met3 ;
  END sel_muxa[1]
  PIN sel_muxa[0] 
    ANTENNAPARTIALMETALAREA 0.5802 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.793 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3485 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5715 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3828 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.512 LAYER met3 ;
  END sel_muxa[0]
  PIN sel_muxb[2] 
    ANTENNADIFFAREA 1.3391 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.5742 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.763 LAYER met2 ;
  END sel_muxb[2]
  PIN sel_muxb[1] 
    ANTENNADIFFAREA 1.9191 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.7779 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7815 LAYER met2 ;
  END sel_muxb[1]
  PIN sel_muxb[0] 
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1909 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.68 LAYER met3 ;
  END sel_muxb[0]
  PIN clk 
    ANTENNAPARTIALMETALAREA 6.3607 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.1255 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 9.729 LAYER met2 ; 
    ANTENNAMAXAREACAR 2.74786 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 10.762 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.130948 LAYER via2 ;
  END clk
  PIN reset 
    ANTENNAPARTIALMETALAREA 5.2223 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.7775 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8875 LAYER met2 ; 
    ANTENNAMAXAREACAR 4.48103 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 20.1138 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0525831 LAYER via2 ;
  END reset
  PIN start 
    ANTENNAPARTIALMETALAREA 0.5802 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.793 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3023 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3405 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.0568 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.44 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 2.86972 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 13.3734 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END start
  PIN error 
  END error
  PIN op_type 
    ANTENNAPARTIALMETALAREA 0.5802 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.793 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1049 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4585 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.1788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.424 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.91408 LAYER met3 ; 
    ANTENNAMAXAREACAR 4.32954 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 19.7026 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0668092 LAYER via3 ;
  END op_type
END fsm

END LIBRARY
