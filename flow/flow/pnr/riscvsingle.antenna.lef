

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO riscvsingle 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.1175 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4795 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1829 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6685 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2409 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.696 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.5958 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.648 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.955 LAYER met4 ; 
    ANTENNAMAXAREACAR 41.3299 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 218.262 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.113964 LAYER via4 ;
  END clk
  PIN reset 
    ANTENNAPARTIALMETALAREA 15.0264 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 80.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.1834 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.921 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END reset
  PIN PC[31] 
    ANTENNAPARTIALMETALAREA 0.1028 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.406 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 8.7975 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.8165 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2588 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.184 LAYER met3 ;
  END PC[31]
  PIN PC[30] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 4.9881 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.7695 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.792 LAYER met3 ;
  END PC[30]
  PIN PC[29] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.6949 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3035 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4448 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.176 LAYER met3 ;
  END PC[29]
  PIN PC[28] 
    ANTENNAPARTIALMETALAREA 0.4773 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2785 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1361 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5425 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.2608 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.528 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9385 LAYER met3 ; 
    ANTENNAMAXAREACAR 7.73389 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 36.8079 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0842518 LAYER via3 ;
  END PC[28]
  PIN PC[27] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1569 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5985 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 37.291 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 199.352 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.3924 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.776 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.7591 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 709.216 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 1071.5 LAYER met5 ;
  END PC[27]
  PIN PC[26] 
    ANTENNAPARTIALMETALAREA 0.1917 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8505 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.6967 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.424 LAYER met3 ;
  END PC[26]
  PIN PC[25] 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.5763 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7735 LAYER met2 ;
  END PC[25]
  PIN PC[24] 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.9831 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6895 LAYER met2 ;
  END PC[24]
  PIN PC[23] 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 13.7513 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.7145 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.91598 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.40039 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 44.7031 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0980173 LAYER via2 ;
  END PC[23]
  PIN PC[22] 
    ANTENNAPARTIALMETALAREA 8.8816 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.421 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.93248 LAYER met2 ; 
    ANTENNAMAXAREACAR 5.16431 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 23.3277 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.118809 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 97.7256 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 522.144 LAYER met3 ;
    ANTENNAGATEAREA 4.88748 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.895 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 130.701 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.193555 LAYER via3 ;
  END PC[22]
  PIN PC[21] 
    ANTENNADIFFAREA 0.7591 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 9.6106 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.096 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.93848 LAYER met2 ; 
    ANTENNAMAXAREACAR 4.7326 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 21.2872 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.066197 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.7288 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.024 LAYER met3 ;
    ANTENNAGATEAREA 3.91598 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.8471 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.1843 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END PC[21]
  PIN PC[20] 
    ANTENNAPARTIALMETALAREA 14.0712 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 69.706 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.93248 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.4552 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 54.9717 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.118807 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 43.8237 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 234.192 LAYER met3 ;
    ANTENNAGATEAREA 3.90998 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.6634 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 114.868 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.118807 LAYER via3 ;
  END PC[20]
  PIN PC[19] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2197 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9275 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 51.8254 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 278.28 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.0419 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 172.636 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.165718 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.9826 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.848 LAYER met4 ;
    ANTENNAGATEAREA 1.961 LAYER met4 ; 
    ANTENNAMAXAREACAR 34.5629 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 181.228 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.165718 LAYER via4 ;
  END PC[19]
  PIN PC[18] 
    ANTENNAPARTIALMETALAREA 0.4749 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2295 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 8.1367 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.5125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 8.0538 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.424 LAYER met3 ;
  END PC[18]
  PIN PC[17] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3107 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3825 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 94.5636 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 505.28 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met3 ; 
    ANTENNAMAXAREACAR 110.266 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 581.915 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.185867 LAYER via3 ;
  END PC[17]
  PIN PC[16] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.3841 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7495 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 36.4656 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 195.424 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.1753 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.89 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via3 ;
  END PC[16]
  PIN PC[15] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.5077 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.3675 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 75.355 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 402.36 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.1868 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.8 LAYER met4 ;
  END PC[15]
  PIN PC[14] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.5273 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.4655 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.6468 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.92 LAYER met3 ;
  END PC[14]
  PIN PC[13] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 6.6219 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.9385 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.8528 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.352 LAYER met3 ;
  END PC[13]
  PIN PC[12] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.3729 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6935 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 10.6206 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.584 LAYER met3 ;
  END PC[12]
  PIN PC[11] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 5.5369 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5135 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3008 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.408 LAYER met3 ;
  END PC[11]
  PIN PC[10] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 6.3293 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4755 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.3428 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.632 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met3 ; 
    ANTENNAMAXAREACAR 5.53233 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 25.7601 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0959988 LAYER via3 ;
  END PC[10]
  PIN PC[9] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 5.4893 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.2755 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 45.8076 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 244.768 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.91598 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.6881 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 110.189 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0929334 LAYER via3 ;
  END PC[9]
  PIN PC[8] 
    ANTENNAPARTIALMETALAREA 0.1917 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8505 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 3.3697 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6775 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 8.1948 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.176 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.89348 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.8785 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.5245 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0837752 LAYER via3 ;
  END PC[8]
  PIN PC[7] 
    ANTENNAPARTIALMETALAREA 0.0965 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3745 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 6.5911 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.7845 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.792 LAYER met3 ;
  END PC[7]
  PIN PC[6] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 3.8275 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.9665 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.5258 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.408 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.93248 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.5304 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 60.2112 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.116522 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 8.9982 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.872 LAYER met4 ;
    ANTENNAGATEAREA 3.90998 LAYER met4 ; 
    ANTENNAMAXAREACAR 23.9552 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 119.443 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END PC[6]
  PIN PC[5] 
    ANTENNAPARTIALMETALAREA 0.4773 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2785 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 5.5803 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.7305 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1588 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.984 LAYER met3 ;
  END PC[5]
  PIN PC[4] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 7.2029 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8435 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.0736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.89348 LAYER met3 ; 
    ANTENNAMAXAREACAR 7.99997 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 38.0199 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.102365 LAYER via3 ;
  END PC[4]
  PIN PC[3] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 7.8371 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.0145 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5048 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.496 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.6126 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 57.7443 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0929334 LAYER via3 ;
  END PC[3]
  PIN PC[2] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.7919 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7885 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.164 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.008 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 38.193 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 206.048 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.87698 LAYER met4 ; 
    ANTENNAMAXAREACAR 63.2013 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 330.641 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.429062 LAYER via4 ;
  END PC[2]
  PIN PC[1] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.0695 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1765 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.792 LAYER met3 ;
  END PC[1]
  PIN PC[0] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.0639 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1485 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 55.4848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 296.856 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met3 ; 
    ANTENNAMAXAREACAR 32.8422 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 171.826 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.113706 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 46.2324 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 247.984 LAYER met4 ;
    ANTENNAGATEAREA 3.916 LAYER met4 ; 
    ANTENNAMAXAREACAR 60.3391 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 316.102 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.268849 LAYER via4 ;
  END PC[0]
  PIN Instr[31] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1413 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5565 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 56.8236 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 304 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8935 LAYER met3 ; 
    ANTENNAMAXAREACAR 27.2044 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 137.2 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.14532 LAYER via3 ;
  END Instr[31]
  PIN Instr[30] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4787 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2225 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 48.3018 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 258.08 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.2031 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 112.766 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.114692 LAYER via3 ;
  END Instr[30]
  PIN Instr[29] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1335 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5355 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.6488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.8924 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 102.569 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0954753 LAYER via3 ;
  END Instr[29]
  PIN Instr[28] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5935 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7965 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 25.2108 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 134.928 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.9376 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 106.912 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0954753 LAYER via3 ;
  END Instr[28]
  PIN Instr[27] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.3397 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5275 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 7.9728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 42.992 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.2556 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 60.5676 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.12486 LAYER via3 ;
  END Instr[27]
  PIN Instr[26] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1049 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4585 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 13.0728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 70.192 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.8908 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 84.3241 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0954753 LAYER via3 ;
  END Instr[26]
  PIN Instr[25] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3919 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7885 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 15.4578 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 82.912 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.0641 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 95.5834 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0954753 LAYER via3 ;
  END Instr[25]
  PIN Instr[24] 
    ANTENNAPARTIALMETALAREA 60.4095 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 301.543 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met2 ; 
    ANTENNAMAXAREACAR 65.3531 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 324.21 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 10.1148 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.416 LAYER met3 ;
    ANTENNAGATEAREA 4.88748 LAYER met3 ; 
    ANTENNAMAXAREACAR 67.4227 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 335.343 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END Instr[24]
  PIN Instr[23] 
    ANTENNAPARTIALMETALAREA 26.443 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 131.936 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.552 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.744 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 40.0548 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 214.096 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 7.8076 LAYER met4 ; 
    ANTENNAMAXAREACAR 13.5221 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 66.7939 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.116412 LAYER via4 ;
  END Instr[23]
  PIN Instr[22] 
    ANTENNAPARTIALMETALAREA 84.5205 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 420.529 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.883 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.7666 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 86.4866 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.104525 LAYER via2 ;
  END Instr[22]
  PIN Instr[21] 
    ANTENNAPARTIALMETALAREA 27.7996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 138.719 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.43 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.76 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 42.1938 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 225.504 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.883 LAYER met4 ; 
    ANTENNAMAXAREACAR 16.3841 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 82.8104 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.152886 LAYER via4 ;
  END Instr[21]
  PIN Instr[20] 
    ANTENNAPARTIALMETALAREA 12.8363 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 63.9555 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.7405 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 71.4353 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0525831 LAYER via2 ;
  END Instr[20]
  PIN Instr[19] 
    ANTENNAPARTIALMETALAREA 8.6506 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.092 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.216 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 104.09 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 555.616 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 7.838 LAYER met4 ; 
    ANTENNAMAXAREACAR 32.3195 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 165.972 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.138336 LAYER via4 ;
  END Instr[19]
  PIN Instr[18] 
    ANTENNAPARTIALMETALAREA 6.8292 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.985 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2418 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.576 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 101.151 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 539.936 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 6.84245 LAYER met4 ; 
    ANTENNAMAXAREACAR 67.7316 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 355.774 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END Instr[18]
  PIN Instr[17] 
    ANTENNAPARTIALMETALAREA 0.1651 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7175 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.5413 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5355 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 107.418 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 573.832 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 8.80345 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.6036 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 94.6637 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.141033 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.6678 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.032 LAYER met4 ;
    ANTENNAGATEAREA 9.78095 LAYER met4 ; 
    ANTENNAMAXAREACAR 18.6719 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 95.0759 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.141033 LAYER via4 ;
  END Instr[17]
  PIN Instr[16] 
    ANTENNAPARTIALMETALAREA 29.4434 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 147.056 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2572 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 25.6398 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 137.216 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.955 LAYER met4 ; 
    ANTENNAMAXAREACAR 24.2166 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 123.939 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.116522 LAYER via4 ;
  END Instr[16]
  PIN Instr[15] 
    ANTENNAPARTIALMETALAREA 59.0825 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 294.724 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8935 LAYER met2 ; 
    ANTENNAMAXAREACAR 21.4315 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 104.839 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0820779 LAYER via2 ;
  END Instr[15]
  PIN Instr[14] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1439 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5635 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 40.2048 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 214.896 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8935 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.3066 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 61.8763 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0837751 LAYER via3 ;
  END Instr[14]
  PIN Instr[13] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2169 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9135 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 23.3118 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 124.8 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.90995 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.9038 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 52.4178 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0751153 LAYER via3 ;
  END Instr[13]
  PIN Instr[12] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3317 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4875 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.1588 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.984 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 60.4835 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 301.337 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END Instr[12]
  PIN Instr[11] 
    ANTENNAPARTIALMETALAREA 52.7128 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 262.941 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met2 ; 
    ANTENNAMAXAREACAR 54.2055 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 268.416 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0929334 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 14.1096 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 76.192 LAYER met3 ;
    ANTENNAGATEAREA 3.916 LAYER met3 ; 
    ANTENNAMAXAREACAR 57.8086 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 287.872 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.146087 LAYER via3 ;
  END Instr[11]
  PIN Instr[10] 
    ANTENNAPARTIALMETALAREA 39.9572 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 199.507 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.392 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.5108 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.528 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9445 LAYER met4 ; 
    ANTENNAMAXAREACAR 11.7919 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 57.5915 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.0797524 LAYER via4 ;
  END Instr[10]
  PIN Instr[9] 
    ANTENNAPARTIALMETALAREA 52.003 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 259.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 11.8587 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 63.712 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.877 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.9018 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 87.1744 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0929334 LAYER via3 ;
  END Instr[9]
  PIN Instr[8] 
    ANTENNAPARTIALMETALAREA 21.007 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 104.874 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.43 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.76 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 58.9038 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 314.624 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8995 LAYER met4 ; 
    ANTENNAMAXAREACAR 22.955 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 116.366 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.16753 LAYER via4 ;
  END Instr[8]
  PIN Instr[7] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1855 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6755 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 64.669 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 345.368 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.5828 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.912 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9445 LAYER met4 ; 
    ANTENNAMAXAREACAR 19.9317 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 102.726 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.138445 LAYER via4 ;
  END Instr[7]
  PIN Instr[6] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2477 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0675 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 53.5258 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 286.408 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.9115 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.081 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 76.9914 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.10608 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 19.6134 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 106.016 LAYER met4 ;
    ANTENNAGATEAREA 5.889 LAYER met4 ; 
    ANTENNAMAXAREACAR 18.4115 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 94.9937 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END Instr[6]
  PIN Instr[5] 
    ANTENNAPARTIALMETALAREA 0.6889 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 3.367 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1101 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4725 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 14.8068 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 79.44 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9385 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.939 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 84.3472 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0661955 LAYER via3 ;
  END Instr[5]
  PIN Instr[4] 
    ANTENNAPARTIALMETALAREA 0.6413 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 3.129 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3135 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3965 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 37.9788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 203.024 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9385 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.4216 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 109.223 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0892134 LAYER via3 ;
  END Instr[4]
  PIN Instr[3] 
    ANTENNAPARTIALMETALAREA 0.3821 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8025 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3905 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7815 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.3628 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.072 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 3.64026 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 17.2839 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END Instr[3]
  PIN Instr[2] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2239 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9485 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.042 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.024 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.8508 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.008 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9385 LAYER met4 ; 
    ANTENNAMAXAREACAR 20.1262 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 99.8776 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.0798079 LAYER via4 ;
  END Instr[2]
  PIN Instr[1] 
  END Instr[1]
  PIN Instr[0] 
  END Instr[0]
  PIN MemWrite 
    ANTENNADIFFAREA 0.7591 LAYER met1 ; 
    ANTENNAPARTIALMETALAREA 0.9841 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 4.816 LAYER met1 ;
  END MemWrite
  PIN ALUResult[31] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 6.9621 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.6395 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 10.4808 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.368 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 58.2006 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 292.706 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[31]
  PIN ALUResult[30] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1387 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5495 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 11.3388 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.944 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 53.2409 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 268.224 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[30]
  PIN ALUResult[29] 
    ANTENNAPARTIALMETALAREA 0.4297 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0405 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 11.7326 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.331 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 9.2526 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.288 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.158 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 97.6624 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[29]
  PIN ALUResult[28] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1387 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5495 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.248 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 28.9346 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 143.649 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[28]
  PIN ALUResult[27] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2883 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2705 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7908 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.688 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 28.9833 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 144.32 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[27]
  PIN ALUResult[26] 
    ANTENNAPARTIALMETALAREA 0.3081 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.463 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1699 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6335 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 16.6294 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 89.152 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 40.7448 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 217.776 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 62.4873 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 325.075 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[26]
  PIN ALUResult[25] 
    ANTENNAPARTIALMETALAREA 0.3345 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5645 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 6.5729 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.6935 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.858 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.376 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.1578 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.312 LAYER met4 ;
  END ALUResult[25]
  PIN ALUResult[24] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2407 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0325 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 11.1348 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 59.856 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.2078 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 147.848 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[24]
  PIN ALUResult[23] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3352 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.505 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4448 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.176 LAYER met3 ;
  END ALUResult[23]
  PIN ALUResult[22] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1036 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.455 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2572 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 43.9944 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 235.568 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met4 ; 
    ANTENNAMAXAREACAR 30.7244 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 159.799 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[22]
  PIN ALUResult[21] 
    ANTENNAPARTIALMETALAREA 0.3345 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5645 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4941 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2995 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.424 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.1283 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 179.901 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[21]
  PIN ALUResult[20] 
    ANTENNAPARTIALMETALAREA 0.0965 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3745 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8343 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0005 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 41.9044 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 223.952 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.955 LAYER met3 ; 
    ANTENNAMAXAREACAR 39.2037 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 200.74 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.116522 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.1838 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.784 LAYER met4 ;
    ANTENNAGATEAREA 1.955 LAYER met4 ; 
    ANTENNAMAXAREACAR 44.4128 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 228.762 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.116522 LAYER via4 ;
  END ALUResult[20]
  PIN ALUResult[19] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2099 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8785 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 11.4588 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.584 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.5515 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 184.803 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[19]
  PIN ALUResult[18] 
    ANTENNAPARTIALMETALAREA 0.3821 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8025 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2169 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9135 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 13.3788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 71.824 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 43.4569 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 219.61 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[18]
  PIN ALUResult[17] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.7223 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4405 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 34.6069 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 185.032 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 52.4988 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 280.464 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 64.6552 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 340.293 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[17]
  PIN ALUResult[16] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.9431 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5445 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 19.2814 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 103.296 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.4668 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 197.019 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.1838 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.784 LAYER met4 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 48.885 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 253.064 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[16]
  PIN ALUResult[15] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8847 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2525 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 36.7076 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 196.232 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 128.584 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 686.72 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 133.395 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 710.315 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[15]
  PIN ALUResult[14] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6061 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8595 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 16.7576 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 89.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 151.166 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 802.472 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.3391 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 51.52 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 81.12 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met5 ; 
    ANTENNAMAXAREACAR 56.6501 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 98.2332 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.789156 LAYER rdlcon ;
  END ALUResult[14]
  PIN ALUResult[13] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2099 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8785 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.9329 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.3934 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[13]
  PIN ALUResult[12] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5879 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7685 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 22.0377 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 118 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.1772 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 156.646 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[12]
  PIN ALUResult[11] 
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 14.1474 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 75.448 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 57.7429 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 291.215 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[11]
  PIN ALUResult[10] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2967 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.858 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.376 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 124.293 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 660.176 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 130.15 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 688.965 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.789156 LAYER via4 ;
    ANTENNADIFFAREA 1.3391 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 268.448 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 406.512 LAYER met5 ;
    ANTENNAGATEAREA 1.955 LAYER met5 ; 
    ANTENNAMAXAREACAR 267.463 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 896.899 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.789156 LAYER rdlcon ;
  END ALUResult[10]
  PIN ALUResult[9] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2337 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9975 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 28.9527 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 154.88 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 50.5147 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 260.709 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[9]
  PIN ALUResult[8] 
    ANTENNAPARTIALMETALAREA 0.3345 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5645 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4983 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3205 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 15.526 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 83.272 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 161.242 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 860.416 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met4 ; 
    ANTENNAMAXAREACAR 89.5919 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 474.675 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[8]
  PIN ALUResult[7] 
    ANTENNAPARTIALMETALAREA 0.1917 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8505 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9183 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4205 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2509 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.8238 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.072 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.9191 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 30.848 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.112 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met5 ; 
    ANTENNAMAXAREACAR 139.529 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 612.423 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.789156 LAYER rdlcon ;
  END ALUResult[7]
  PIN ALUResult[6] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2113 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8855 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.1996 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 129.536 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[6]
  PIN ALUResult[5] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 3.2857 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2575 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4648 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.616 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.8802 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 68.4036 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[5]
  PIN ALUResult[4] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4493 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0755 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.0853 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.92 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 98.2068 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 524.24 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met4 ; 
    ANTENNAMAXAREACAR 109.409 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 579.566 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ALUResult[4]
  PIN ALUResult[3] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2449 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0535 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1168 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.76 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9775 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.7165 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 168.325 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ALUResult[3]
  PIN ALUResult[2] 
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.4772 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.344 LAYER met3 ;
  END ALUResult[2]
  PIN ALUResult[1] 
    ANTENNADIFFAREA 0.7591 LAYER met1 ; 
    ANTENNAPARTIALMETALAREA 1.6981 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 8.386 LAYER met1 ;
  END ALUResult[1]
  PIN ALUResult[0] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3737 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6975 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 59.6238 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 318.464 LAYER met3 ;
  END ALUResult[0]
  PIN WriteData[31] 
    ANTENNAPARTIALMETALAREA 0.4297 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0405 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2113 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8855 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 80.3928 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 429.232 LAYER met3 ;
  END WriteData[31]
  PIN WriteData[30] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1049 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4585 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 88.6128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 473.072 LAYER met3 ;
  END WriteData[30]
  PIN WriteData[29] 
    ANTENNAPARTIALMETALAREA 0.3081 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.463 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1179 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4935 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 47.329 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 252.888 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.5828 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.912 LAYER met4 ;
  END WriteData[29]
  PIN WriteData[28] 
    ANTENNAPARTIALMETALAREA 0.1028 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.406 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.1223 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4405 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 90.514 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 483.208 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.9191 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.0338 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.984 LAYER met4 ;
  END WriteData[28]
  PIN WriteData[27] 
    ANTENNAPARTIALMETALAREA 0.4509 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.177 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1036 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.455 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 57.202 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 305.544 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.3228 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.192 LAYER met4 ;
  END WriteData[27]
  PIN WriteData[26] 
    ANTENNAPARTIALMETALAREA 0.4876 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.592 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.8238 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.072 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.9191 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 56.96 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 89.28 LAYER met5 ;
  END WriteData[26]
  PIN WriteData[25] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2883 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2705 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 27.4548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 146.896 LAYER met3 ;
  END WriteData[25]
  PIN WriteData[24] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4381 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0195 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 45.7308 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 244.368 LAYER met3 ;
  END WriteData[24]
  PIN WriteData[23] 
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 82.1604 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 438.184 LAYER met3 ;
  END WriteData[23]
  PIN WriteData[22] 
    ANTENNADIFFAREA 1.9191 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 60.336 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 90.504 LAYER met5 ;
  END WriteData[22]
  PIN WriteData[21] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6019 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8385 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 58.8708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 314.448 LAYER met3 ;
  END WriteData[21]
  PIN WriteData[20] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2113 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8855 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 60.3378 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 322.272 LAYER met3 ;
  END WriteData[20]
  PIN WriteData[19] 
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 47.9334 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 255.64 LAYER met3 ;
  END WriteData[19]
  PIN WriteData[18] 
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 77.3064 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 412.296 LAYER met3 ;
  END WriteData[18]
  PIN WriteData[17] 
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 76.4694 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 407.832 LAYER met3 ;
  END WriteData[17]
  PIN WriteData[16] 
    ANTENNAPARTIALMETALAREA 0.1028 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.406 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 5.8743 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2005 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 94.4838 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 504.384 LAYER met3 ;
  END WriteData[16]
  PIN WriteData[15] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1049 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4585 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 79.2258 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 423.008 LAYER met3 ;
  END WriteData[15]
  PIN WriteData[14] 
    ANTENNAPARTIALMETALAREA 0.7153 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4685 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3205 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4315 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 80.7588 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 431.184 LAYER met3 ;
  END WriteData[14]
  PIN WriteData[13] 
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 32.0184 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 170.76 LAYER met3 ;
  END WriteData[13]
  PIN WriteData[12] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3289 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4735 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.8528 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.352 LAYER met3 ;
  END WriteData[12]
  PIN WriteData[11] 
    ANTENNAPARTIALMETALAREA 66.4576 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 354.432 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.3391 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.6678 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.032 LAYER met4 ;
  END WriteData[11]
  PIN WriteData[10] 
    ANTENNAPARTIALMETALAREA 0.4297 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0405 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3121 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3895 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 66.7848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 356.656 LAYER met3 ;
  END WriteData[10]
  PIN WriteData[9] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3751 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7045 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.3391 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 65.1108 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 347.728 LAYER met3 ;
  END WriteData[9]
  PIN WriteData[8] 
    ANTENNAPARTIALMETALAREA 0.1917 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8505 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1563 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6105 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 20.4168 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 109.36 LAYER met3 ;
  END WriteData[8]
  PIN WriteData[7] 
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3374 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.128 LAYER met3 ;
  END WriteData[7]
  PIN WriteData[6] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4101 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8795 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.0788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.024 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.0068 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.048 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.7591 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 17.792 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.528 LAYER met5 ;
  END WriteData[6]
  PIN WriteData[5] 
    ANTENNAPARTIALMETALAREA 71.3326 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 380.432 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.6678 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.032 LAYER met4 ;
  END WriteData[5]
  PIN WriteData[4] 
    ANTENNADIFFAREA 0.7591 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 56.656 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 84.984 LAYER met5 ;
  END WriteData[4]
  PIN WriteData[3] 
    ANTENNAPARTIALMETALAREA 0.1917 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8505 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8147 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 47.3796 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 253.632 LAYER met3 ;
  END WriteData[3]
  PIN WriteData[2] 
    ANTENNAPARTIALMETALAREA 0.5086 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.704 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.7591 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.6678 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.032 LAYER met4 ;
  END WriteData[2]
  PIN WriteData[1] 
    ANTENNADIFFAREA 1.9191 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 77.2434 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 411.96 LAYER met3 ;
  END WriteData[1]
  PIN WriteData[0] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.7979 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8185 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.7591 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7508 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.808 LAYER met3 ;
  END WriteData[0]
  PIN ReadData[31] 
    ANTENNAPARTIALMETALAREA 0.1441 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.3925 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7915 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 67.7389 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 361.736 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 43.754 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 228.185 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.0929334 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.2607 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.856 LAYER met4 ;
    ANTENNAGATEAREA 6.8845 LAYER met4 ; 
    ANTENNAMAXAREACAR 44.2276 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 230.779 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.138417 LAYER via4 ;
  END ReadData[31]
  PIN ReadData[30] 
    ANTENNAPARTIALMETALAREA 0.2129 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1335 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5355 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 38.5016 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 205.8 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 33.5856 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 180.064 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.895 LAYER met4 ; 
    ANTENNAMAXAREACAR 27.9548 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 144.601 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.159546 LAYER via4 ;
  END ReadData[30]
  PIN ReadData[29] 
    ANTENNAPARTIALMETALAREA 0.6719 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2515 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.1419 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5385 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 49.6864 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 265.456 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met3 ; 
    ANTENNAMAXAREACAR 58.6597 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 308.133 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.133604 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 27.9546 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 150.032 LAYER met4 ;
    ANTENNAGATEAREA 5.895 LAYER met4 ; 
    ANTENNAMAXAREACAR 63.4018 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 333.584 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.172489 LAYER via4 ;
  END ReadData[29]
  PIN ReadData[28] 
    ANTENNAPARTIALMETALAREA 0.1028 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.406 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2137 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8975 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.634 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.848 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.3924 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.776 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 29.76 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.48 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.895 LAYER met5 ; 
    ANTENNAMAXAREACAR 40.8246 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 195.679 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.323513 LAYER rdlcon ;
  END ReadData[28]
  PIN ReadData[27] 
    ANTENNAPARTIALMETALAREA 0.4876 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.592 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 18.3114 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 99.072 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.895 LAYER met4 ; 
    ANTENNAMAXAREACAR 29.2247 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 153.85 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.206233 LAYER via4 ;
  END ReadData[27]
  PIN ReadData[26] 
    ANTENNAPARTIALMETALAREA 0.0965 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3745 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8861 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2595 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.216 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 47.6766 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 255.216 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.895 LAYER met4 ; 
    ANTENNAMAXAREACAR 41.3596 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 214.341 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.153971 LAYER via4 ;
  END ReadData[26]
  PIN ReadData[25] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1413 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5565 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 109.695 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 586.88 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.922 LAYER met3 ; 
    ANTENNAMAXAREACAR 49.784 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 256.097 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.207405 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 38.9704 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 205.128 LAYER met4 ;
    ANTENNAGATEAREA 4.8995 LAYER met4 ; 
    ANTENNAMAXAREACAR 57.738 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 297.964 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.338031 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 297.824 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 450.576 LAYER met5 ;
    ANTENNAGATEAREA 5.883 LAYER met5 ; 
    ANTENNAMAXAREACAR 108.363 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 374.553 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.784342 LAYER rdlcon ;
  END ReadData[25]
  PIN ReadData[24] 
    ANTENNAPARTIALMETALAREA 95.7583 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 511.168 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9505 LAYER met3 ; 
    ANTENNAMAXAREACAR 45.6307 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 236.793 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.10649 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 28.4577 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 152.24 LAYER met4 ;
    ANTENNAGATEAREA 5.895 LAYER met4 ; 
    ANTENNAMAXAREACAR 50.4581 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 262.618 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.134425 LAYER via4 ;
  END ReadData[24]
  PIN ReadData[23] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3751 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7045 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 27.3049 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 146.088 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.488 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 214.59 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.133604 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 28.9353 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 155.728 LAYER met4 ;
    ANTENNAGATEAREA 6.8785 LAYER met4 ; 
    ANTENNAMAXAREACAR 45.6946 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 237.23 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.175345 LAYER via4 ;
  END ReadData[23]
  PIN ReadData[22] 
    ANTENNAPARTIALMETALAREA 86.3296 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 460.416 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 72.7761 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 390.016 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.928 LAYER met4 ; 
    ANTENNAMAXAREACAR 32.9082 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 166.289 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.267209 LAYER via4 ;
  END ReadData[22]
  PIN ReadData[21] 
    ANTENNAPARTIALMETALAREA 0.8956 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.768 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.0414 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.632 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.928 LAYER met4 ; 
    ANTENNAMAXAREACAR 31.7469 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 164.046 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.133604 LAYER via4 ;
  END ReadData[21]
  PIN ReadData[20] 
    ANTENNAPARTIALMETALAREA 0.3797 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7535 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1491 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5775 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 82.2908 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 440.288 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 51.4237 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 269.157 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.199695 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 72.7116 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 388.736 LAYER met4 ;
    ANTENNAGATEAREA 3.928 LAYER met4 ; 
    ANTENNAMAXAREACAR 69.9348 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 368.123 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.199695 LAYER via4 ;
  END ReadData[20]
  PIN ReadData[19] 
    ANTENNAPARTIALMETALAREA 0.5249 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5165 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1673 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6265 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 73.7647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 394.352 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.961 LAYER met3 ; 
    ANTENNAMAXAREACAR 45.8265 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 239.645 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.102232 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 10.7862 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.408 LAYER met4 ;
    ANTENNAGATEAREA 2.9445 LAYER met4 ; 
    ANTENNAMAXAREACAR 49.4897 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 259.821 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.133604 LAYER via4 ;
  END ReadData[19]
  PIN ReadData[18] 
    ANTENNAPARTIALMETALAREA 0.4876 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.592 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 91.395 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 489.792 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.928 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.6108 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 203.371 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.214947 LAYER via4 ;
  END ReadData[18]
  PIN ReadData[17] 
    ANTENNAPARTIALMETALAREA 0.4297 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0405 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2291 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9745 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 69.2152 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 370.08 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9445 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.0554 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 185.7 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.131694 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 59.1498 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 315.936 LAYER met4 ;
    ANTENNAGATEAREA 3.928 LAYER met4 ; 
    ANTENNAMAXAREACAR 51.1139 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 266.132 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.133604 LAYER via4 ;
  END ReadData[17]
  PIN ReadData[16] 
    ANTENNAPARTIALMETALAREA 0.2393 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0885 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1387 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5495 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.634 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.848 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.3924 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.776 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 48.256 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 76.224 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.928 LAYER met5 ; 
    ANTENNAMAXAREACAR 91.812 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 438.081 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.337208 LAYER rdlcon ;
  END ReadData[16]
  PIN ReadData[15] 
    ANTENNAPARTIALMETALAREA 8.784 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.176 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 6.8845 LAYER met5 ; 
    ANTENNAMAXAREACAR 52.081 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 268.38 LAYER met5 ;
    ANTENNAMAXCUTCAR 0.226567 LAYER rdlcon ;
  END ReadData[15]
  PIN ReadData[14] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1751 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6475 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 91.0188 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 485.904 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.9026 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 140.278 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0853076 LAYER via3 ;
  END ReadData[14]
  PIN ReadData[13] 
    ANTENNAPARTIALMETALAREA 0.3345 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5645 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5193 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4255 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 83.3688 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 445.104 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 28.4423 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 147.082 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0853076 LAYER via3 ;
  END ReadData[13]
  PIN ReadData[12] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4143 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9005 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 92.7417 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 495.088 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.9115 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.1037 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.485 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0935038 LAYER via3 ;
  END ReadData[12]
  PIN ReadData[11] 
    ANTENNAPARTIALMETALAREA 77.4213 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 412.904 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.0045 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 134.115 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.118082 LAYER via3 ;
  END ReadData[11]
  PIN ReadData[10] 
    ANTENNAPARTIALMETALAREA 0.7153 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4685 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3121 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3895 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 73.1508 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 390.608 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.928 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.5789 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 126.679 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0857843 LAYER via3 ;
  END ReadData[10]
  PIN ReadData[9] 
    ANTENNAPARTIALMETALAREA 75.9204 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 404.904 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 32.2008 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 165.165 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.114692 LAYER via3 ;
  END ReadData[9]
  PIN ReadData[8] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1621 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 42.1648 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 225.816 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9835 LAYER met3 ; 
    ANTENNAMAXAREACAR 49.5048 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 260.155 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.226538 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 91.8537 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 490.352 LAYER met4 ;
    ANTENNAGATEAREA 3.934 LAYER met4 ; 
    ANTENNAMAXAREACAR 72.8535 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 384.799 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.226538 LAYER via4 ;
  END ReadData[8]
  PIN ReadData[7] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2561 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1095 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 64.0488 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 342.064 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.934 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.0672 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 113.572 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.114692 LAYER via3 ;
  END ReadData[7]
  PIN ReadData[6] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1153 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4865 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 63.5418 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 339.36 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.8664 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 193.223 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.090544 LAYER via3 ;
  END ReadData[6]
  PIN ReadData[5] 
    ANTENNAPARTIALMETALAREA 0.2869 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3265 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6075 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8665 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 77.1048 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 411.696 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.1655 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 216.994 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0725979 LAYER via3 ;
  END ReadData[5]
  PIN ReadData[4] 
    ANTENNAPARTIALMETALAREA 0.4297 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0405 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8343 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0005 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 77.641 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 414.552 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.3998 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.936 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.9505 LAYER met4 ; 
    ANTENNAMAXAREACAR 5.32827 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 24.9093 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.131639 LAYER via4 ;
  END ReadData[4]
  PIN ReadData[3] 
    ANTENNAPARTIALMETALAREA 73.1004 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 389.864 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 39.9194 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 209.679 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.12486 LAYER via3 ;
  END ReadData[3]
  PIN ReadData[2] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2827 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2425 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 64.4808 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 344.368 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 40.7232 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 212.209 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.12486 LAYER via3 ;
  END ReadData[2]
  PIN ReadData[1] 
    ANTENNAPARTIALMETALAREA 0.6201 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3205 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4315 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 66.3768 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 354.48 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.9444 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 184.035 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0725979 LAYER via3 ;
  END ReadData[1]
  PIN ReadData[0] 
    ANTENNAPARTIALMETALAREA 0.5725 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7545 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.231 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7735 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 68.4168 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 365.36 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.967 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.1363 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 215.187 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.0954753 LAYER via3 ;
  END ReadData[0]
END riscvsingle

END LIBRARY
