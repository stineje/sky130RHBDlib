** sch_path: lib/xschem/HA.sch
**.subckt HA SUM COUT A B
*.opin SUM
*.opin COUT
*.ipin A
*.ipin B
x1 SUM A B VDD VSS XOR2X1
x2 COUT A B VDD VSS AND2X1
**.ends
.end
