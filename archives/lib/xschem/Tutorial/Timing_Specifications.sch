v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 1280 -1930 1460 -1930 {}
L 4 1400 -1830 1420 -1810 {}
L 4 1420 -1810 1440 -1830 {}
L 4 1440 -1830 1460 -1810 {}
L 4 1460 -1810 1480 -1830 {}
L 4 1480 -1830 1500 -1810 {}
L 4 1400 -1810 1420 -1830 {}
L 4 1420 -1830 1440 -1810 {}
L 4 1440 -1810 1460 -1830 {}
L 4 1460 -1830 1480 -1810 {}
L 4 1480 -1810 1500 -1830 {}
L 4 1420 -1830 1500 -1830 {}
L 4 1420 -1810 1500 -1810 {}
L 4 1090 -1700 1110 -1720 {}
L 4 1110 -1720 1130 -1700 {}
L 4 1130 -1700 1150 -1720 {}
L 4 1150 -1720 1170 -1700 {}
L 4 1170 -1700 1190 -1720 {}
L 4 1090 -1720 1110 -1700 {}
L 4 1110 -1700 1130 -1720 {}
L 4 1130 -1720 1150 -1700 {}
L 4 1150 -1700 1170 -1720 {}
L 4 1170 -1720 1190 -1700 {}
L 4 1090 -1720 1170 -1720 {}
L 4 1090 -1700 1170 -1700 {}
L 4 1350 -1700 1370 -1720 {}
L 4 1370 -1720 1390 -1700 {}
L 4 1390 -1700 1410 -1720 {}
L 4 1410 -1720 1430 -1700 {}
L 4 1350 -1720 1370 -1700 {}
L 4 1370 -1700 1390 -1720 {}
L 4 1390 -1720 1410 -1700 {}
L 4 1410 -1700 1430 -1720 {}
L 4 1340 -1710 1350 -1720 {}
L 4 1340 -1710 1350 -1700 {}
L 4 1430 -1700 1450 -1720 {}
L 4 1450 -1720 1470 -1700 {}
L 4 1470 -1700 1490 -1720 {}
L 4 1430 -1720 1450 -1700 {}
L 4 1450 -1700 1470 -1720 {}
L 4 1470 -1720 1490 -1700 {}
L 4 1510 -1700 1530 -1720 {}
L 4 1530 -1720 1550 -1700 {}
L 4 1510 -1720 1530 -1700 {}
L 4 1530 -1700 1550 -1720 {}
L 4 1240 -1890 1280 -1930 {}
L 4 1180 -1740 1180 -1730 {}
L 4 1180 -1720 1180 -1710 {}
L 4 1180 -1700 1180 -1690 {}
L 4 1180 -1680 1180 -1670 {}
L 4 1340 -1720 1340 -1710 {}
L 4 1340 -1700 1340 -1690 {}
L 4 1340 -1680 1340 -1670 {}
L 4 1340 -1740 1340 -1730 {}
L 4 1500 -1830 1520 -1810 {}
L 4 1500 -1810 1520 -1830 {}
L 4 1490 -1700 1510 -1720 {}
L 4 1490 -1720 1510 -1700 {}
L 4 1180 -1670 1190 -1680 {}
L 4 1180 -1670 1190 -1660 {}
L 4 1250 -1680 1260 -1670 {}
L 4 1250 -1660 1260 -1670 {}
L 4 1190 -1670 1250 -1670 {}
L 4 1260 -1670 1270 -1680 {}
L 4 1260 -1670 1270 -1660 {}
L 4 1330 -1680 1340 -1670 {}
L 4 1330 -1660 1340 -1670 {}
L 4 1270 -1670 1330 -1670 {}
L 4 1260 -1620 1270 -1630 {}
L 4 1260 -1620 1270 -1610 {}
L 4 1400 -1630 1410 -1620 {}
L 4 1400 -1610 1410 -1620 {}
L 4 1270 -1620 1400 -1620 {}
L 4 1260 -1560 1270 -1570 {}
L 4 1260 -1560 1270 -1550 {}
L 4 1500 -1570 1510 -1560 {}
L 4 1500 -1550 1510 -1560 {}
L 4 1270 -1560 1500 -1560 {}
L 4 1090 -1890 1240 -1890 {}
L 4 1090 -1830 1400 -1830 {}
L 4 1090 -1810 1400 -1810 {}
L 4 1330 -1720 1340 -1710 {}
L 4 1330 -1700 1340 -1710 {}
L 4 1190 -1720 1330 -1720 {}
L 4 1190 -1700 1330 -1700 {}
L 4 1180 -1750 1190 -1760 {}
L 4 1180 -1750 1190 -1740 {}
L 4 1330 -1760 1340 -1750 {}
L 4 1330 -1740 1340 -1750 {}
L 4 1190 -1750 1330 -1750 {}
L 4 1180 -1760 1180 -1750 {}
L 4 1340 -1760 1340 -1750 {}
L 4 1410 -1850 1420 -1860 {}
L 4 1400 -1860 1420 -1860 {}
L 4 1400 -1860 1410 -1850 {}
L 4 1500 -1860 1510 -1850 {}
L 4 1500 -1860 1520 -1860 {}
L 4 1510 -1850 1520 -1860 {}
L 4 1550 -1720 1560 -1710 {}
L 4 1550 -1700 1560 -1710 {}
L 4 1350 -1720 1550 -1720 {}
L 4 1350 -1700 1550 -1700 {}
L 4 1520 -1700 1540 -1700 {}
L 4 1520 -1720 1540 -1720 {}
L 4 1430 -1930 1540 -1930 {}
L 4 1860 -1620 1880 -1600 {}
L 4 1880 -1600 1900 -1620 {}
L 4 1900 -1620 1920 -1600 {}
L 4 1860 -1600 1880 -1620 {}
L 4 1880 -1620 1900 -1600 {}
L 4 1900 -1600 1920 -1620 {}
L 4 1940 -1620 1960 -1600 {}
L 4 1940 -1600 1960 -1620 {}
L 4 1960 -1620 2010 -1620 {}
L 4 1960 -1600 2010 -1600 {}
L 4 1680 -1720 1720 -1720 {}
L 4 1720 -1720 1740 -1760 {}
L 4 1740 -1760 1840 -1760 {}
L 4 1860 -1760 1880 -1720 {}
L 4 1880 -1720 1980 -1720 {}
L 4 2000 -1720 2020 -1760 {}
L 4 2020 -1760 2060 -1760 {}
L 4 1730 -1780 1740 -1790 {}
L 4 1730 -1780 1740 -1770 {}
L 4 2000 -1790 2010 -1780 {}
L 4 2000 -1770 2010 -1780 {}
L 4 1740 -1780 1960 -1780 {}
L 4 1780 -1660 1800 -1680 {}
L 4 1780 -1680 1800 -1660 {}
L 4 1800 -1680 1810 -1670 {}
L 4 1800 -1660 1810 -1670 {}
L 4 1770 -1670 1780 -1680 {}
L 4 1770 -1670 1780 -1660 {}
L 4 1780 -1680 1800 -1680 {}
L 4 1780 -1660 1800 -1660 {}
L 4 1810 -1670 1820 -1680 {}
L 4 1820 -1680 2040 -1680 {}
L 4 1810 -1670 1820 -1660 {}
L 4 1820 -1660 2040 -1660 {}
L 4 1760 -1680 1770 -1670 {}
L 4 1700 -1680 1760 -1680 {}
L 4 1760 -1660 1770 -1670 {}
L 4 1700 -1660 1760 -1660 {}
L 4 1920 -1620 1930 -1610 {}
L 4 1930 -1610 1940 -1620 {}
L 4 1920 -1600 1930 -1610 {}
L 4 1930 -1610 1940 -1600 {}
L 4 1880 -1620 1940 -1620 {}
L 4 1880 -1600 1940 -1600 {}
L 4 1700 -1620 1860 -1620 {}
L 4 1700 -1600 1860 -1600 {}
L 4 1730 -1570 1740 -1580 {}
L 4 1730 -1570 1740 -1560 {}
L 4 1800 -1580 1810 -1570 {}
L 4 1800 -1560 1810 -1570 {}
L 4 1760 -1570 1800 -1570 {}
L 4 1810 -1570 1820 -1580 {}
L 4 1810 -1570 1820 -1560 {}
L 4 1940 -1580 1950 -1570 {}
L 4 1940 -1560 1950 -1570 {}
L 4 1950 -1570 1960 -1580 {}
L 4 1950 -1570 1960 -1560 {}
L 4 2000 -1580 2010 -1570 {}
L 4 2000 -1560 2010 -1570 {}
L 4 1840 -1760 1860 -1760 {}
L 4 1980 -1720 2000 -1720 {}
L 4 1960 -1780 2000 -1780 {}
L 4 2040 -1680 2080 -1680 {}
L 4 2040 -1660 2080 -1660 {}
L 4 2010 -1620 2080 -1620 {}
L 4 2010 -1600 2080 -1600 {}
L 4 1820 -1570 1940 -1570 {}
L 4 960 -2110 960 -1490 {}
L 4 980 -2110 980 -1490 {}
L 4 2130 -2110 2130 -1510 {}
L 4 2150 -2110 2150 -1510 {}
L 4 1590 -2110 1590 -1490 {}
L 4 1610 -2110 1610 -1490 {}
L 4 2250 -1870 2260 -1860 {}
L 4 2260 -1860 2270 -1870 {}
L 4 2250 -1870 2270 -1870 {}
L 4 2250 -1870 2250 -1830 {}
L 4 2250 -1830 2270 -1830 {}
L 4 2270 -1870 2270 -1830 {}
L 4 2400 -1870 2480 -1870 {}
L 4 2400 -1830 2480 -1830 {}
L 4 2270 -1850 2310 -1850 {}
L 4 2620 -1860 2630 -1870 {}
L 4 2610 -1870 2620 -1860 {}
L 4 2610 -1870 2630 -1870 {}
L 4 2630 -1870 2630 -1830 {}
L 4 2610 -1830 2630 -1830 {}
L 4 2610 -1870 2610 -1830 {}
L 4 2560 -1850 2600 -1850 {}
L 4 2260 -1880 2260 -1870 {}
L 4 2620 -1880 2620 -1870 {}
L 4 2240 -1850 2250 -1850 {}
L 4 2630 -1850 2640 -1850 {}
L 4 2550 -1850 2560 -1850 {}
L 4 2310 -1850 2320 -1850 {}
L 4 2410 -1630 2430 -1610 {}
L 4 2430 -1610 2450 -1630 {}
L 4 2450 -1630 2470 -1610 {}
L 4 2410 -1610 2430 -1630 {}
L 4 2430 -1630 2450 -1610 {}
L 4 2450 -1610 2470 -1630 {}
L 4 2490 -1630 2510 -1610 {}
L 4 2490 -1610 2510 -1630 {}
L 4 2510 -1630 2560 -1630 {}
L 4 2510 -1610 2560 -1610 {}
L 4 2230 -1730 2270 -1730 {}
L 4 2270 -1730 2290 -1770 {}
L 4 2290 -1770 2390 -1770 {}
L 4 2410 -1770 2430 -1730 {}
L 4 2430 -1730 2530 -1730 {}
L 4 2550 -1730 2570 -1770 {}
L 4 2570 -1770 2610 -1770 {}
L 4 2280 -1790 2290 -1800 {}
L 4 2280 -1790 2290 -1780 {}
L 4 2550 -1800 2560 -1790 {}
L 4 2550 -1780 2560 -1790 {}
L 4 2290 -1790 2510 -1790 {}
L 4 2330 -1670 2350 -1690 {}
L 4 2330 -1690 2350 -1670 {}
L 4 2350 -1690 2360 -1680 {}
L 4 2350 -1670 2360 -1680 {}
L 4 2320 -1680 2330 -1690 {}
L 4 2320 -1680 2330 -1670 {}
L 4 2330 -1690 2350 -1690 {}
L 4 2330 -1670 2350 -1670 {}
L 4 2360 -1680 2370 -1690 {}
L 4 2370 -1690 2590 -1690 {}
L 4 2360 -1680 2370 -1670 {}
L 4 2370 -1670 2590 -1670 {}
L 4 2310 -1690 2320 -1680 {}
L 4 2250 -1690 2310 -1690 {}
L 4 2310 -1670 2320 -1680 {}
L 4 2250 -1670 2310 -1670 {}
L 4 2470 -1630 2480 -1620 {}
L 4 2480 -1620 2490 -1630 {}
L 4 2470 -1610 2480 -1620 {}
L 4 2480 -1620 2490 -1610 {}
L 4 2430 -1630 2490 -1630 {}
L 4 2430 -1610 2490 -1610 {}
L 4 2250 -1630 2410 -1630 {}
L 4 2250 -1610 2410 -1610 {}
L 4 2280 -1580 2290 -1590 {}
L 4 2280 -1580 2290 -1570 {}
L 4 2310 -1590 2320 -1580 {}
L 4 2310 -1570 2320 -1580 {}
L 4 2320 -1580 2330 -1590 {}
L 4 2320 -1580 2330 -1570 {}
L 4 2390 -1770 2410 -1770 {}
L 4 2530 -1730 2550 -1730 {}
L 4 2510 -1790 2550 -1790 {}
L 4 2590 -1690 2630 -1690 {}
L 4 2590 -1670 2630 -1670 {}
L 4 2560 -1630 2630 -1630 {}
L 4 2560 -1610 2630 -1610 {}
L 4 2680 -2090 2680 -1490 {}
L 4 2700 -2090 2700 -1490 {}
L 4 2680 -2110 2680 -2090 {}
L 4 2700 -2110 2700 -2080 {}
L 4 2320 -1850 2370 -1850 {}
L 4 2500 -1850 2550 -1850 {}
L 4 2370 -1850 2380 -1850 {}
L 4 2600 -1850 2610 -1850 {}
L 4 2280 -1580 2320 -1580 {}
L 4 1740 -1570 1760 -1570 {}
L 4 1960 -1570 2000 -1570 {}
L 4 2320 -1580 2370 -1580 {}
L 4 1180 -1750 1190 -1750 {}
L 4 1180 -1670 1190 -1670 {}
L 4 1250 -1670 1270 -1670 {}
L 4 1330 -1750 1340 -1750 {}
L 4 1330 -1670 1340 -1670 {}
L 4 1260 -1620 1270 -1620 {}
L 4 1400 -1620 1410 -1620 {}
L 4 1260 -1560 1270 -1560 {}
L 4 1500 -1560 1510 -1560 {}
L 4 1730 -1570 1740 -1570 {}
L 4 1800 -1570 1820 -1570 {}
L 4 1940 -1570 1960 -1570 {}
L 4 2000 -1570 2010 -1570 {}
L 4 2230 -1690 2250 -1690 {}
L 4 2230 -1670 2250 -1670 {}
L 4 2230 -1630 2250 -1630 {}
L 4 2230 -1610 2250 -1610 {}
L 4 2410 -1590 2420 -1580 {}
L 4 2410 -1570 2420 -1580 {}
L 4 2370 -1580 2420 -1580 {}
L 4 2280 -1530 2290 -1540 {}
L 4 2280 -1530 2290 -1520 {}
L 4 2280 -1530 2320 -1530 {}
L 4 2320 -1530 2370 -1530 {}
L 4 2400 -1540 2410 -1530 {}
L 4 2400 -1520 2410 -1530 {}
L 4 2370 -1530 2410 -1530 {}
L 4 1520 -1830 1560 -1830 {}
L 4 1520 -1810 1560 -1810 {}
L 4 2540 -1840 2560 -1860 {}
L 4 2290 -1840 2310 -1860 {}
L 4 1680 -1870 1690 -1860 {}
L 4 1690 -1860 1700 -1870 {}
L 4 1680 -1870 1700 -1870 {}
L 4 1680 -1870 1680 -1830 {}
L 4 1680 -1830 1700 -1830 {}
L 4 1700 -1870 1700 -1830 {}
L 4 1830 -1870 1910 -1870 {}
L 4 1830 -1830 1910 -1830 {}
L 4 1700 -1850 1740 -1850 {}
L 4 2050 -1860 2060 -1870 {}
L 4 2040 -1870 2050 -1860 {}
L 4 2040 -1870 2060 -1870 {}
L 4 2060 -1870 2060 -1830 {}
L 4 2040 -1830 2060 -1830 {}
L 4 2040 -1870 2040 -1830 {}
L 4 1990 -1850 2030 -1850 {}
L 4 1690 -1880 1690 -1870 {}
L 4 2050 -1880 2050 -1870 {}
L 4 1670 -1850 1680 -1850 {}
L 4 2060 -1850 2070 -1850 {}
L 4 1980 -1850 1990 -1850 {}
L 4 1740 -1850 1750 -1850 {}
L 4 1750 -1850 1800 -1850 {}
L 4 1930 -1850 1980 -1850 {}
L 4 1800 -1850 1810 -1850 {}
L 4 2030 -1850 2040 -1850 {}
L 4 1970 -1840 1990 -1860 {}
L 4 1740 -1840 1760 -1860 {}
L 4 960 -2110 2700 -2110 {}
L 4 960 -2730 960 -2110 {}
L 4 980 -2730 980 -2110 {}
L 4 1320 -2650 1330 -2640 {}
L 4 1330 -2640 1340 -2650 {}
L 4 1320 -2650 1340 -2650 {}
L 4 1320 -2650 1320 -2610 {}
L 4 1320 -2610 1340 -2610 {}
L 4 1340 -2650 1340 -2610 {}
L 4 1330 -2660 1330 -2650 {}
L 4 1310 -2630 1320 -2630 {}
L 4 1320 -2600 1330 -2590 {}
L 4 1330 -2590 1340 -2600 {}
L 4 1320 -2600 1340 -2600 {}
L 4 1320 -2600 1320 -2560 {}
L 4 1320 -2560 1340 -2560 {}
L 4 1340 -2600 1340 -2560 {}
L 4 1330 -2610 1330 -2600 {}
L 4 1310 -2580 1320 -2580 {}
L 4 1320 -2550 1330 -2540 {}
L 4 1330 -2540 1340 -2550 {}
L 4 1320 -2550 1340 -2550 {}
L 4 1320 -2550 1320 -2510 {}
L 4 1340 -2550 1340 -2510 {}
L 4 1330 -2560 1330 -2550 {}
L 4 1310 -2530 1320 -2530 {}
L 4 1320 -2510 1340 -2510 {}
L 4 1320 -2500 1330 -2490 {}
L 4 1330 -2490 1340 -2500 {}
L 4 1320 -2500 1340 -2500 {}
L 4 1320 -2500 1320 -2460 {}
L 4 1320 -2460 1340 -2460 {}
L 4 1340 -2500 1340 -2460 {}
L 4 1330 -2510 1330 -2500 {}
L 4 1310 -2480 1320 -2480 {}
L 4 1340 -2630 1350 -2630 {}
L 4 1340 -2580 1350 -2580 {}
L 4 1340 -2530 1350 -2530 {}
L 4 1340 -2480 1350 -2480 {}
L 4 1390 -2640 1390 -2600 {}
L 4 1390 -2640 1430 -2640 {}
L 4 1390 -2600 1430 -2600 {}
L 4 1660 -2560 1670 -2550 {}
L 4 1670 -2550 1680 -2560 {}
L 4 1660 -2560 1680 -2560 {}
L 4 1660 -2560 1660 -2520 {}
L 4 1680 -2560 1680 -2520 {}
L 4 1670 -2570 1670 -2560 {}
L 4 1650 -2540 1660 -2540 {}
L 4 1660 -2510 1670 -2500 {}
L 4 1670 -2500 1680 -2510 {}
L 4 1660 -2510 1680 -2510 {}
L 4 1660 -2510 1660 -2470 {}
L 4 1660 -2470 1680 -2470 {}
L 4 1680 -2510 1680 -2470 {}
L 4 1670 -2520 1670 -2510 {}
L 4 1650 -2490 1660 -2490 {}
L 4 1680 -2540 1690 -2540 {}
L 4 1680 -2490 1690 -2490 {}
L 4 1370 -2630 1390 -2630 {}
L 4 1350 -2580 1360 -2580 {}
L 4 1350 -2630 1370 -2630 {}
L 4 1440 -2620 1460 -2620 {}
L 4 1460 -2620 1460 -2600 {}
L 4 1350 -2530 1480 -2530 {}
L 4 1350 -2480 1560 -2480 {}
L 4 1660 -2520 1680 -2520 {}
L 4 1460 -2550 1480 -2550 {}
L 4 1460 -2600 1460 -2550 {}
L 4 1540 -2500 1560 -2500 {}
L 4 1540 -2540 1540 -2500 {}
L 4 1530 -2540 1540 -2540 {}
L 4 1620 -2490 1650 -2490 {}
L 4 1540 -2540 1650 -2540 {}
L 4 1670 -2660 1670 -2570 {}
L 4 1360 -2580 1380 -2580 {}
L 4 1380 -2610 1380 -2580 {}
L 4 1380 -2610 1390 -2610 {}
L 4 1670 -2560 1670 -2520 {}
L 4 1330 -2650 1330 -2510 {}
L 4 1770 -2670 1780 -2660 {}
L 4 1780 -2660 1790 -2670 {}
L 4 1770 -2670 1790 -2670 {}
L 4 1770 -2670 1770 -2630 {}
L 4 1770 -2630 1790 -2630 {}
L 4 1790 -2670 1790 -2630 {}
L 4 1780 -2680 1780 -2670 {}
L 4 1760 -2650 1770 -2650 {}
L 4 1770 -2620 1780 -2610 {}
L 4 1780 -2610 1790 -2620 {}
L 4 1770 -2620 1790 -2620 {}
L 4 1770 -2620 1770 -2580 {}
L 4 1770 -2580 1790 -2580 {}
L 4 1790 -2620 1790 -2580 {}
L 4 1780 -2630 1780 -2620 {}
L 4 1760 -2600 1770 -2600 {}
L 4 1770 -2570 1780 -2560 {}
L 4 1780 -2560 1790 -2570 {}
L 4 1770 -2570 1790 -2570 {}
L 4 1770 -2570 1770 -2530 {}
L 4 1790 -2570 1790 -2530 {}
L 4 1780 -2580 1780 -2570 {}
L 4 1760 -2550 1770 -2550 {}
L 4 1770 -2530 1790 -2530 {}
L 4 1770 -2520 1780 -2510 {}
L 4 1780 -2510 1790 -2520 {}
L 4 1770 -2520 1790 -2520 {}
L 4 1770 -2520 1770 -2480 {}
L 4 1770 -2480 1790 -2480 {}
L 4 1790 -2520 1790 -2480 {}
L 4 1780 -2530 1780 -2520 {}
L 4 1760 -2500 1770 -2500 {}
L 4 1790 -2650 1800 -2650 {}
L 4 1790 -2600 1800 -2600 {}
L 4 1790 -2550 1800 -2550 {}
L 4 1790 -2500 1800 -2500 {}
L 4 1840 -2660 1840 -2620 {}
L 4 1840 -2660 1880 -2660 {}
L 4 1840 -2620 1880 -2620 {}
L 4 2110 -2590 2120 -2580 {}
L 4 2120 -2580 2130 -2590 {}
L 4 2110 -2590 2130 -2590 {}
L 4 2110 -2590 2110 -2550 {}
L 4 2130 -2590 2130 -2550 {}
L 4 2120 -2600 2120 -2590 {}
L 4 2100 -2570 2110 -2570 {}
L 4 2110 -2530 2120 -2520 {}
L 4 2120 -2520 2130 -2530 {}
L 4 2110 -2530 2130 -2530 {}
L 4 2110 -2530 2110 -2490 {}
L 4 2110 -2490 2130 -2490 {}
L 4 2130 -2530 2130 -2490 {}
L 4 2120 -2540 2120 -2530 {}
L 4 2130 -2570 2140 -2570 {}
L 4 2130 -2510 2140 -2510 {}
L 4 1820 -2650 1840 -2650 {}
L 4 1800 -2600 1810 -2600 {}
L 4 1800 -2650 1820 -2650 {}
L 4 1910 -2640 1910 -2620 {}
L 4 2110 -2550 2130 -2550 {}
L 4 1910 -2620 1910 -2570 {}
L 4 2120 -2690 2120 -2600 {}
L 4 1810 -2600 1830 -2600 {}
L 4 1830 -2630 1830 -2600 {}
L 4 1830 -2630 1840 -2630 {}
L 4 2120 -2590 2120 -2550 {}
L 4 1780 -2670 1780 -2530 {}
L 4 1840 -2540 1860 -2550 {}
L 4 1840 -2560 1860 -2550 {}
L 4 1840 -2560 1840 -2540 {}
L 4 1800 -2550 1830 -2550 {}
L 4 1850 -2550 1930 -2550 {}
L 4 1840 -2490 1860 -2500 {}
L 4 1840 -2510 1860 -2500 {}
L 4 1840 -2510 1840 -2490 {}
L 4 1800 -2500 1830 -2500 {}
L 4 1850 -2500 2010 -2500 {}
L 4 1910 -2570 1930 -2570 {}
L 4 1890 -2640 1910 -2640 {}
L 4 1990 -2520 2010 -2520 {}
L 4 1840 -2650 1890 -2640 {}
L 4 1980 -2550 1990 -2550 {}
L 4 2010 -2520 2060 -2520 {}
L 4 2060 -2520 2110 -2510 {}
L 4 1990 -2550 1990 -2520 {}
L 4 1930 -2570 1980 -2550 {}
L 4 1900 -2480 1910 -2470 {}
L 4 1850 -2490 1850 -2480 {}
L 4 1850 -2490 1860 -2490 {}
L 4 1860 -2540 1860 -2530 {}
L 4 1860 -2540 1870 -2540 {}
L 4 2240 -2730 2240 -2110 {}
L 4 2260 -2730 2260 -2110 {}
L 4 2350 -2620 2350 -2580 {}
L 4 2570 -2360 2610 -2360 {}
L 4 2680 -2730 2680 -2110 {}
L 4 2700 -2730 2700 -2110 {}
L 4 960 -2730 2705 -2730 {}
L 4 2180 -1490 2700 -1490 {}
A 4 1465 -1895 65.19202405202648 175.6012946450045 36.86989764584399 {}
A 4 1455 -1895 65.19202405202648 327.5288077091515 36.86989764584399 {}
A 4 2395 -1850 20.6155281280883 75.96375653207353 208.0724869358529 {}
A 4 2485 -1850 20.6155281280883 255.9637565320735 208.0724869358529 {}
A 4 1825 -1850 20.6155281280883 75.96375653207353 208.0724869358529 {}
A 4 1915 -1850 20.6155281280883 255.9637565320735 208.0724869358529 {}
A 4 1420 -2620 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 1460 -2540 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 1485 -2505 57.0087712549569 37.8749836510982 67.38013505195957 {}
A 4 1485 -2575 57.0087712549569 254.7448812969423 67.38013505195957 {}
A 4 1540 -2490 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 1565 -2455 57.0087712549569 37.8749836510982 67.38013505195957 {}
A 4 1565 -2525 57.0087712549569 254.7448812969423 67.38013505195957 {}
A 4 1615 -2490 7.071067811865476 315 360 {}
A 4 1870 -2640 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 1910 -2560 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 1935 -2525 57.0087712549569 37.8749836510982 67.38013505195957 {}
A 4 1935 -2595 57.0087712549569 254.7448812969423 67.38013505195957 {}
A 4 1990 -2510 22.3606797749979 296.565051177078 126.869897645844 {}
A 4 2015 -2475 57.0087712549569 37.8749836510982 67.38013505195957 {}
A 4 2015 -2545 57.0087712549569 254.7448812969423 67.38013505195957 {}
A 4 2065 -2510 7.071067811865476 315 360 {}
A 4 1850 -2490 50.99019513592785 348.6900675259798 90 {}
A 4 1885 -2535 57.0087712549569 232.1250163489018 53.13010235415595 {}
A 4 2555 -2565 205.5480479109447 175.8150838748816 98.36983225023684 {}
A 4 2380 -2455 7.071067811865476 315 360 {}
A 4 2445 -2390 7.071067811865476 315 360 {}
A 4 2490 -2370 7.071067811865476 315 360 {}
A 4 2350 -2575 7.071067811865476 315 360 {}
A 4 2530 -2360 7.071067811865476 315 360 {}
A 4 2575 -2360 7.071067811865476 315 360 {}
A 4 2355 -2360 7.071067811865476 315 360 {}
T {CLK
} 1030 -1910 0 0 0.5 0.5 {}
T {t_setup
} 1220 -1660 0 0 0.2 0.2 {layer=6 hcenter=true}
T {t_hold
} 1300 -1660 0 0 0.2 0.2 {layer=6 hcenter=true}
T {t_ccq "contamination
           clock to q"
} 1330 -1620 0 0 0.2 0.2 {layer=6 hcenter=true}
T {t_pcq "propagation
           clock to q"
} 1390 -1560 0 0 0.2 0.2 {layer=6 hcenter=true}
T {stable
} 1210 -1730 0 0 0.1 0.1 {layer=11}
T {output(s)
} 990 -1830 0 0 0.4 0.4 {}
T {input(s)
} 1000 -1730 0 0 0.4 0.4 {}
T {Sequential Timing Specifications
} 1290 -2100 0 0 0.6 0.6 {layer=1 hcenter=true}
T {"t_setup" is the amount of time signal needs to be stable/unchanging BEFORE clock edge.

"t_hold" is the amount of time signal needs to be stable/unchanging AFTER clock edge.

"Contamination clock to q" is the fastest time the output take to stabilize.

"Propagation clock to q" is the slowest time the output can take to stabilize.

} 1280 -2060 0 0 0.19 0.19 {layer=3 hcenter=true}
T {stable
} 1290 -1730 0 0 0.1 0.1 {layer=11}
T {metastable
} 1450 -1840 0 0 0.1 0.1 {layer=7}
T {stable
} 1540 -1840 0 0 0.1 0.1 {layer=11}
T {"Aperature Window"
} 1210 -1770 0 0 0.2 0.2 {}
T {fastest time to stabilize.} 1330 -1910 0 0 0.19 0.19 {layer=3}
T {slowest time to stabilize.} 1460 -1910 0 0 0.19 0.19 {layer=3}
T {CLK
} 1650 -1740 0 0 0.4 0.4 {}
T {T_C (Clock Period)
} 1860 -1800 0 0 0.2 0.2 {layer=6 hcenter=true}
T {Q1
} 1660 -1680 0 0 0.4 0.4 {}
T {D2
} 1660 -1620 0 0 0.4 0.4 {}
T {t_pcq
} 1770 -1560 0 0 0.2 0.2 {layer=6 hcenter=true}
T {t_pd
} 1880 -1560 0 0 0.2 0.2 {layer=6 hcenter=true}
T {t_setup
} 1980 -1560 0 0 0.2 0.2 {layer=6 hcenter=true}
T {Setup Time Constraint
} 1650 -2110 0 0 0.6 0.6 {layer=1}
T {For setup time constraints, we look at the slowest responses, i.e. propagation delays.
To find the maximum clock frequency this circuit can run at, we have to add:

 - t_pcq    -> slowest time for clock to be stable.
 - t_pd     -> time for comb logic to become stable
 - t_setup -> time for flop 2 to capture D2

Therfore
   T_C  >= t_pcq + t_pd + t_setup
   t_pd <= T_C - (t_pcq + t_setup)

t_pcq and t_setup are usually specified by flip-flop.} 1870 -2070 0 0 0.19 0.19 {layer=3 hcenter=true}
T {Q1} 2330 -1870 0 0 0.3 0.3 {layer=3 hcenter=true}
T {Combinational Logic} 2390 -1860 0 0 0.19 0.19 {layer=3}
T {D2} 2530 -1870 0 0 0.3 0.3 {layer=3 hcenter=true}
T {CLK} 2260 -1890 0 0 0.1 0.1 {layer=3}
T {CLK} 2620 -1890 0 0 0.1 0.1 {layer=3}
T {R1} 2260 -1830 0 0 0.1 0.1 {layer=3}
T {R2} 2620 -1830 0 0 0.1 0.1 {layer=3}
T {CLK
} 2190 -1750 0 0 0.4 0.4 {}
T {T_C (Clock Period)
} 2350 -1810 0 0 0.2 0.2 {layer=6 hecenter=true}
T {Q1
} 2190 -1690 0 0 0.4 0.4 {}
T {D2
} 2190 -1630 0 0 0.4 0.4 {}
T {t_ccq
} 2300 -1570 0 0 0.19 0.19 {layer=6 hcenter=true}
T {t_cd
} 2360 -1570 0 0 0.2 0.2 {layer=6 hecenter=true}
T {t_hold
} 2330 -1530 0 0 0.2 0.2 {layer=6 hecenter=true}
T {Hold Time Constraint
} 2190 -2110 0 0 0.6 0.6 {layer=1}
T {For hold time contstraints, we look at the fasted responses, i.e. contamination delays.
To find the maximum clock frequency this circuit can run at, we have to add:

 - t_pcq    -> fastest time for clock to be stable.
 - t_pd:    -> fastest time for comb logic to become stable
 - t_hold  -> time for flop 2 to capture D2

Therfore
    t_hold <= t_cd+ t_ccq                   
    t_cd   >= t_hold - t_ccq

Again, t_hold and t_ccq are usually specified by the flop.

* Notice that the clock period, T_C, does not appear here.
  Setup Time is what controls the max frequency, but hold
  time CANNOT be violated. } 2210 -2070 0 0 0.19 0.19 {layer=3 hcenter= rue}
T {Q1} 1780 -1870 0 0 0.3 0.3 {layer=3 hcenter=true}
T {Combinational Logic} 1820 -1860 0 0 0.19 0.19 {layer=3}
T {D2} 1960 -1870 0 0 0.3 0.3 {layer=3 hcenter=true}
T {CLK} 1690 -1890 0 0 0.1 0.1 {layer=3}
T {CLK} 2050 -1890 0 0 0.1 0.1 {layer=3}
T {R1} 1690 -1830 0 0 0.1 0.1 {layer=3}
T {R2} 2050 -1830 0 0 0.1 0.1 {layer=3}
T {Timing Analysis Example
} 1220 -2730 0 0 0.6 0.6 {layer=1 hcenter=true}
T {  FLIP-FLOPS        PER GATE
--------------    ------------
t_ccq = 30 ps     t_cd = 25 ps

t_pcq = 80 ps     t_pd = 40 ps

t_setup = 50 ps

t_hold = 60 ps

What is Clock Period, T_C?} 1130 -2690 0 0 0.3 0.3 {layer=3 hcenter=true}
T {CLK} 1330 -2680 0 0 0.2 0.2 {layer=3 hcenter=true}
T {CLK} 1670 -2680 0 0 0.2 0.2 {layer=3 hcenter=true}
T {A} 1360 -2650 0 0 0.2 0.2 {layer=3 hcenter=true}
T {B} 1360 -2600 0 0 0.2 0.2 {layer=3 hcenter=true}
T {C} 1360 -2550 0 0 0.2 0.2 {layer=3 hcenter=true}
T {D} 1360 -2500 0 0 0.2 0.2 {layer=3 hcenter=true}
T {N1} 1470 -2620 0 0 0.2 0.2 {layer=3 hcenter=true}
T {X'} 1640 -2560 0 0 0.2 0.2 {layer=3 hcenter=true}
T {Y'} 1640 -2510 0 0 0.2 0.2 {layer=3 hcenter=true}
T {X} 1700 -2560 0 0 0.2 0.2 {layer=3 hcenter=true}
T {Y} 1700 -2510 0 0 0.2 0.2 {layer=3 hcenter=true}
T {T_C  >= t_pcq + t_pd + t_setup
t_hold <= t_ccq + t_cd} 1500 -2690 0 0 0.3 0.3 {layer=3 hcenter=true}
T {fastest path---^} 1520 -2480 0 0 0.2 0.2 {layer=3 hcenter=true}
T {slowest path---^} 1520 -2500 0 0 0.2 0.2 {layer=3 hcenter=true}
T {SETUP TIME CALCULATION:
Slowest path goes through 3 gates:} 1150 -2460 0 0 0.3 0.3 {layer=6 hcenter=true}
T {AND2} 1410 -2620 0 0 0.2 0.2 {layer=3 hcenter=true}
T {OR2} 1500 -2540 0 0 0.2 0.2 {layer=3 hcenter=true}
T {NOR2} 1580 -2490 0 0 0.2 0.2 {layer=3 hcenter=true}
T {N2} 1550 -2530 0 0 0.2 0.2 {layer=3 hcenter=true}
T {HOLD TIME CALCULATION:
Fastest path goes through only 1 gate:} 1520 -2450 0 0 0.3 0.3 {layer=6 hcenter=true}
T {CLK} 1780 -2700 0 0 0.2 0.2 {layer=3 hcenter=true}
T {CLK} 2120 -2700 0 0 0.2 0.2 {layer=3 hcenter=true}
T {A} 1810 -2670 0 0 0.2 0.2 {layer=3 hcenter=true}
T {B} 1810 -2620 0 0 0.2 0.2 {layer=3 hcenter=true}
T {C} 1810 -2570 0 0 0.2 0.2 {layer=3 hcenter=true}
T {D} 1810 -2520 0 0 0.2 0.2 {layer=3 hcenter=true}
T {N1} 1920 -2640 0 0 0.2 0.2 {layer=3 hcenter=true}
T {X'} 2090 -2580 0 0 0.2 0.2 {layer=3 hcenter=true}
T {Y'} 2090 -2530 0 0 0.2 0.2 {layer=3 hcenter=true}
T {X} 2150 -2580 0 0 0.2 0.2 {layer=3 hcenter=true}
T {Y} 2150 -2530 0 0 0.2 0.2 {layer=3 hcenter=true}
T {There are now 2 fastest paths} 1900 -2530 0 0 0.2 0.2 {layer=3 hcenter=true}
T {AND2} 1860 -2640 0 0 0.2 0.2 {layer=3 hcenter=true}
T {OR2} 1950 -2570 0 0 0.2 0.2 {layer=3 hcenter=true}
T {NOR2} 2030 -2520 0 0 0.2 0.2 {layer=3 hcenter=true}
T {N2} 2000 -2550 0 0 0.2 0.2 {layer=3 hcenter=true}
T {FIXED SETUP and HOLD TIME CALCULATIONS:
- By adding buffers between the shortest paths, we increase
  the contamination delay t_cd, which increases our hold time.

There are now 2 fastest paths:} 1985 -2460 0 0 0.3 0.3 {layer=6 hcenter=true}
T {<-- still slowest path} 1970 -2610 0 0 0.2 0.2 {layer=3 hcenter=true}
T {BUF} 1850 -2550 0 0 0.15 0.15 {layer=3 hcenter=true}
T {BUF} 1850 -2500 0 0 0.15 0.15 {layer=3 hcenter=true}
T {Added buffers} 1950 -2480 0 0 0.2 0.2 {layer=3 hcenter=true}
T {DELAY} 2290 -2490 1 0 0.2 0.2 {layer=3 hcenter=true}
T {AREA} 2450 -2310 0 0 0.2 0.2 {layer=3 hcenter=true}
T {- minimal area implementation
- high delay} 2470 -2640 0 0 0.2 0.2 {layer=3 hcenter=true}
T {- minimal delay implementation
- high area} 2570 -2435 0 0 0.2 0.2 {layer=3 hcenter=true}
T {- ideal implementation
- minimal area and delay} 2535 -2525 0 0 0.2 0.2 {layer=3 hcenter=true}
T {Area/Delay Tradeoff} 2480 -2710 0 0 0.6 0.6 {layer=1 hcenter=true}
T {  - (A)-> AND2 -> (N1) -> OR2 
    -> (N2) -> NOR2 -> (Y') 
  - t_pd = 3 * 40ps = 120ps} 1145 -2420 0 0 0.3 0.3 {layer=4 hcenter=true}
T {t_pcq and t_setup are given:} 1125 -2350 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  - t_pcq = 80ps
  - t_setup = 50ps
} 1095 -2325 0 0 0.3 0.3 {layer=4 hcenter=true}
T {Therefore, our maximum clock period is:} 1175 -2270 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  - T_C >= 80ps + (3)(40)ps + 50ps
        >= 250ps
  - f_clk = 1 / T_C = 4,000,000,000 = 4 GHz} 1195 -2250 0 0 0.3 0.3 {layer=4 hcenter=true}
T {  (D) -> NOR2 -> (Y')  
  -> t_cd = 25ps} 1465 -2410 0 0 0.3 0.3 {layer=4 hcenter=true}
T {t_ccq is given:} 1420 -2355 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  -> t_ccq = 30ps} 1450 -2330 0 0 0.3 0.3 {layer=4 hcenter=true}
T {Therefore,} 1405 -2295 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  -> 60ps  <= 30ps + 25ps
                 !<= 55ps} 1490 -2270 0 0 0.3 0.3 {layer=4 hcenter=true}
T {HOLD TIMING IS VIOLATED!!!} 1515 -2215 0 0 0.3 0.3 {layer=7 hcenter=true}
T {  (D) -> BUF -> (D') -> NOR2 -> (Y')  
  (C) -> BUF -> (D') ->  OR2 -> (X')
  -> t_cd = 2 * 25ps
              = 50ps} 1910 -2370 0 0 0.3 0.3 {layer=4 hcenter=true}
T {Therefore,} 1785 -2290 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  -> 60ps <= 30ps + 50ps
               <= 80ps   --FIXED--} 1880 -2270 0 0 0.3 0.3 {layer=4 hcenter=true}
T {NEW SETUP TIME CALCULATION:
  - Slowest path is still the same, so T_C stays the same.} 1960 -2225 0 0 0.3 0.3 {layer=6 hcenter=true}
T {  (D) -> BUF -> (D') -> NOR2 -> (Y') 
  (C) -> BUF -> (D') ->  OR2 -> (X')
      -> t_cd = 2 * 25ps = 50ps} 1890 -2185 0 0 0.3 0.3 {layer=4 hcenter=true}
T {FIXED SETUP and HOLD TIME CALCULATIONS:

- Usually tools like Vivado will figure this
  out for you.} 2475 -2255 0 0 0.3 0.3 {layer=6 hcenter=true}
N 1260 -1910 1260 -1900 {
lab=#net1}
N 1260 -1890 1260 -1880 {
lab=#net2}
N 1260 -1870 1260 -1860 {
lab=#net3}
N 1260 -1850 1260 -1840 {
lab=#net4}
N 1260 -1830 1260 -1820 {
lab=#net5}
N 1260 -1810 1260 -1800 {
lab=#net6}
N 1260 -1770 1260 -1760 {
lab=#net7}
N 1260 -1750 1260 -1740 {
lab=#net8}
N 1260 -1730 1260 -1720 {
lab=#net9}
N 1260 -1710 1260 -1700 {
lab=#net10}
N 1260 -1690 1260 -1680 {
lab=#net11}
N 1260 -1670 1260 -1660 {
lab=#net12}
N 1260 -1630 1260 -1620 {
lab=#net13}
N 1260 -1610 1260 -1600 {
lab=#net14}
N 1260 -1590 1260 -1580 {
lab=#net15}
N 1260 -1570 1260 -1560 {
lab=#net16}
N 1410 -1850 1410 -1840 {
lab=#net17}
N 1410 -1830 1410 -1820 {
lab=#net18}
N 1410 -1770 1410 -1760 {
lab=#net19}
N 1410 -1750 1410 -1740 {
lab=#net20}
N 1410 -1730 1410 -1720 {
lab=#net21}
N 1410 -1710 1410 -1700 {
lab=#net22}
N 1410 -1670 1410 -1660 {
lab=#net23}
N 1410 -1650 1410 -1640 {
lab=#net24}
N 1410 -1630 1410 -1620 {
lab=#net25}
N 1260 -1930 1260 -1920 {
lab=#net26}
N 1510 -1830 1510 -1820 {
lab=#net27}
N 1510 -1770 1510 -1760 {
lab=#net28}
N 1510 -1750 1510 -1740 {
lab=#net29}
N 1510 -1730 1510 -1720 {
lab=#net30}
N 1510 -1710 1510 -1700 {
lab=#net31}
N 1510 -1690 1510 -1680 {
lab=#net32}
N 1510 -1670 1510 -1660 {
lab=#net33}
N 1510 -1650 1510 -1640 {
lab=#net34}
N 1510 -1630 1510 -1620 {
lab=#net35}
N 1510 -1610 1510 -1600 {
lab=#net36}
N 1510 -1590 1510 -1580 {
lab=#net37}
N 1510 -1570 1510 -1560 {
lab=#net38}
N 1730 -1780 1730 -1770 {
lab=#net39}
N 1730 -1760 1730 -1750 {
lab=#net40}
N 1730 -1740 1730 -1730 {
lab=#net41}
N 1730 -1720 1730 -1710 {
lab=#net42}
N 1730 -1700 1730 -1690 {
lab=#net43}
N 1730 -1660 1730 -1650 {
lab=#net44}
N 1730 -1640 1730 -1630 {
lab=#net45}
N 1730 -1620 1730 -1610 {
lab=#net46}
N 1730 -1600 1730 -1590 {
lab=#net47}
N 1730 -1580 1730 -1570 {
lab=#net48}
N 1730 -1560 1730 -1550 {
lab=#net49}
N 1730 -1540 1730 -1530 {
lab=#net50}
N 1730 -1680 1730 -1670 {
lab=#net51}
N 2010 -1780 2010 -1770 {
lab=#net52}
N 2010 -1760 2010 -1750 {
lab=#net53}
N 2010 -1740 2010 -1730 {
lab=#net54}
N 2010 -1720 2010 -1710 {
lab=#net55}
N 2010 -1700 2010 -1690 {
lab=#net56}
N 2010 -1660 2010 -1650 {
lab=#net57}
N 2010 -1640 2010 -1630 {
lab=#net58}
N 2010 -1620 2010 -1610 {
lab=#net59}
N 2010 -1600 2010 -1590 {
lab=#net60}
N 2010 -1560 2010 -1550 {
lab=#net61}
N 2010 -1540 2010 -1530 {
lab=#net62}
N 2010 -1680 2010 -1670 {
lab=#net63}
N 1810 -1680 1810 -1670 {
lab=#net64}
N 1810 -1640 1810 -1630 {
lab=#net65}
N 1810 -1620 1810 -1610 {
lab=#net66}
N 1810 -1600 1810 -1590 {
lab=#net67}
N 1810 -1580 1810 -1570 {
lab=#net68}
N 1810 -1560 1810 -1550 {
lab=#net69}
N 1810 -1660 1810 -1650 {
lab=#net70}
N 1950 -1640 1950 -1630 {
lab=#net71}
N 1950 -1620 1950 -1610 {
lab=#net72}
N 1950 -1600 1950 -1590 {
lab=#net73}
N 1950 -1580 1950 -1570 {
lab=#net74}
N 1950 -1560 1950 -1550 {
lab=#net75}
N 1810 -1540 1810 -1530 {
lab=#net76}
N 1950 -1540 1950 -1530 {
lab=#net77}
N 2010 -1580 2010 -1570 {
lab=#net78}
N 2280 -1790 2280 -1780 {
lab=#net79}
N 2280 -1760 2280 -1750 {
lab=#net80}
N 2280 -1740 2280 -1730 {
lab=#net81}
N 2280 -1720 2280 -1710 {
lab=#net82}
N 2280 -1700 2280 -1690 {
lab=#net83}
N 2280 -1660 2280 -1650 {
lab=#net84}
N 2280 -1640 2280 -1630 {
lab=#net85}
N 2280 -1620 2280 -1610 {
lab=#net86}
N 2280 -1600 2280 -1590 {
lab=#net87}
N 2280 -1580 2280 -1570 {
lab=#net88}
N 2280 -1560 2280 -1550 {
lab=#net89}
N 2280 -1540 2280 -1530 {
lab=#net90}
N 2280 -1680 2280 -1670 {
lab=#net91}
N 2560 -1790 2560 -1780 {
lab=#net92}
N 2560 -1770 2560 -1760 {
lab=#net93}
N 2560 -1750 2560 -1740 {
lab=#net94}
N 2560 -1730 2560 -1720 {
lab=#net95}
N 2560 -1710 2560 -1700 {
lab=#net96}
N 2560 -1670 2560 -1660 {
lab=#net97}
N 2560 -1650 2560 -1640 {
lab=#net98}
N 2560 -1630 2560 -1620 {
lab=#net99}
N 2560 -1610 2560 -1600 {
lab=#net100}
N 2560 -1570 2560 -1560 {
lab=#net101}
N 2560 -1550 2560 -1540 {
lab=#net102}
N 2560 -1690 2560 -1680 {
lab=#net103}
N 2320 -1680 2320 -1670 {
lab=#net104}
N 2320 -1640 2320 -1630 {
lab=#net105}
N 2320 -1620 2320 -1610 {
lab=#net106}
N 2320 -1600 2320 -1590 {
lab=#net107}
N 2320 -1580 2320 -1570 {
lab=#net108}
N 2320 -1560 2320 -1550 {
lab=#net109}
N 2320 -1660 2320 -1650 {
lab=#net110}
N 2320 -1540 2320 -1530 {
lab=#net111}
N 2560 -1590 2560 -1580 {
lab=#net112}
N 2420 -1640 2420 -1630 {
lab=#net113}
N 2420 -1620 2420 -1610 {
lab=#net114}
N 2420 -1600 2420 -1590 {
lab=#net115}
N 2420 -1580 2420 -1570 {
lab=#net116}
N 1260 -1650 1260 -1640 {
lab=#net117}
N 1260 -1790 1260 -1780 {
lab=#net118}
N 1510 -1810 1510 -1800 {
lab=#net119}
N 1510 -1790 1510 -1780 {
lab=#net120}
N 1510 -1850 1510 -1840 {
lab=#net121}
N 1410 -1810 1410 -1800 {
lab=#net122}
N 1410 -1790 1410 -1780 {
lab=#net123}
N 1410 -1690 1410 -1680 {
lab=#net124}
N 2320 -1700 2320 -1690 {
lab=#net125}
N 1340 -2630 1390 -2630 {
lab=#net126}
N 1390 -2630 1440 -2620 {
lab=#net126}
N 1440 -2620 1460 -2620 {
lab=#net126}
N 1460 -2620 1460 -2550 {
lab=#net126}
N 1460 -2550 1480 -2550 {
lab=#net126}
N 1480 -2550 1530 -2540 {
lab=#net126}
N 1530 -2540 1540 -2540 {
lab=#net126}
N 1540 -2540 1540 -2500 {
lab=#net126}
N 1540 -2500 1560 -2500 {
lab=#net126}
N 1560 -2500 1570 -2490 {
lab=#net126}
N 1340 -2480 1560 -2480 {
lab=#net126}
N 1560 -2480 1570 -2490 {
lab=#net126}
N 1570 -2490 1660 -2490 {
lab=#net126}
N 1790 -2500 2010 -2500 {
lab=#net127}
N 1790 -2550 1930 -2550 {
lab=#net128}
N 1930 -2550 1980 -2570 {
lab=#net128}
N 1980 -2570 2110 -2570 {
lab=#net128}
N 2010 -2500 2060 -2500 {
lab=#net127}
N 2060 -2500 2110 -2510 {
lab=#net127}
N 2300 -2320 2640 -2320 {
lab=#net129}
N 2300 -2660 2300 -2320 {
lab=#net129}
N 2350 -2575 2390 -2615 {
lab=#net130}
N 2390 -2615 2430 -2615 {
lab=#net130}
N 2355 -2360 2475 -2500 {
lab=#net131}
N 2475 -2500 2515 -2500 {
lab=#net131}
N 2540 -2410 2575 -2360 {
lab=#net132}
N 2490 -2410 2540 -2410 {
lab=#net132}
C {devices/title.sym} 1120 -1490 0 0 {name=l1 author="Ryan Ridley"}
