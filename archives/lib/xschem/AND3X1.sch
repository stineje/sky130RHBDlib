** sch_path: archives/lib/xschem/AND3X1.sch
**.subckt AND3X1 Y A B C
*.opin Y
*.ipin A
*.ipin B
*.ipin C
x1 net1 A B C VDD VSS NAND3X1
x2 Y net1 VDD VSS INVX1
**.ends
.end
