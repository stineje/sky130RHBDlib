v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {NAND2X1.sym} -60 0 0 0 {name=x1 VDD=VDD VSS=VSS}
C {INVX1.sym} 40 0 0 0 {name=x2 VDD=VDD VSS=VSS}
C {devices/opin.sym} 80 0 0 0 {name=p1 lab=Y}
C {devices/ipin.sym} -120 -20 0 0 {name=p2 lab=A}
C {devices/ipin.sym} -120 20 0 0 {name=p3 lab=B}
